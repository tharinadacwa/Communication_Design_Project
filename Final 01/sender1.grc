options:
  parameters:
    author: User
    generate_options: qt_gui
    id: qpskk1111
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import threading
      import time
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, file_path="", interval=2.0, max_packet_size=32):
              gr.basic_block.__init__(
                  self,
                  name="File to PDU (chunked, ack-based retransmit)",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.interval = float(interval)
              self.max_packet_size = int(max_packet_size)

              # Output: PDUs to transmitter
              self.message_port_register_out(pmt.intern("pdus"))

              # Input: ACKs as bit-level PDUs
              self.message_port_register_in(pmt.intern("ack_bits"))
              self.set_msg_handler(pmt.intern("ack_bits"), self.handle_ack_bits)

              # Threading + ACK control
              self._stop_event = threading.Event()
              self._ack_event = threading.Event()
              self._ack_lock = threading.Lock()
              self._expected_ack = None

              self._thread = threading.Thread(target=self._send_loop)
              self._thread.daemon = True

          def start(self):
              self._stop_event.clear()
              self._thread.start()
              return super().start()

          def stop(self):
              self._stop_event.set()
              self._ack_event.set()  # Unblock any waiting
              self._thread.join()
              return super().stop()

          def _send_loop(self):
              try:
                  with open(self.file_path, 'rb') as f:
                      data = f.read()
              except Exception as e:
                  print(f"[FileToPDU] Error reading file: {str(e)}")
                  return

              # Break data into chunks (1 byte reserved for packet number)
              chunks = [
                  data[i:i + self.max_packet_size - 1]
                  for i in range(0, len(data), self.max_packet_size - 1)
              ]

              packet_number = 1

              for chunk in chunks:
                  if self._stop_event.is_set():
                      break

                  # Add packet number as first byte
                  full_packet = bytes([packet_number]) + chunk
                  payload = pmt.init_u8vector(len(full_packet), list(full_packet))
                  pdu = pmt.cons(pmt.make_dict(), payload)

                  # Set expected ACK number
                  with self._ack_lock:
                      self._expected_ack = packet_number
                      self._ack_event.clear()

                  retry_count = 0
                  max_retries = 100

                  while not self._stop_event.is_set() and retry_count < max_retries:
                      self.message_port_pub(pmt.intern("pdus"), pdu)
                      print(f"[FileToPDU] Sent packet #{packet_number:02X}, attempt {retry_count + 1}")

                      ack_received = self._ack_event.wait(timeout=self.interval)

                      if ack_received:
                          break  # Got ACK, move on
                      else:
                          print(f"[FileToPDU] Timeout waiting for ACK for packet #{packet_number:02X}, retrying...")
                          retry_count += 1

                  #if retry_count == max_retries:
                      #print(f"[FileToPDU] No ACK after {max_retries} attempts. Skipping packet #{packet_number:02X}.")

                  if retry_count == max_retries:
                      print(f"[FileToPDU] No ACK after {max_retries} attempts for packet #{packet_number:02X}.")
                      print("[FileToPDU] Error occurred. Try again.")
                      self._stop_event.set()
                      return  # Exit the loop early

                  # Increment and wrap packet number
                  packet_number = (packet_number + 1) & 0xFF
                  if packet_number == 0x00:
                      packet_number = 0x01

          def handle_ack_bits(self, msg):
              """Receives physical-layer ACKs as PDUs (e.g., [0xAA, packet_num])"""
              try:
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)

                  if not pmt.is_u8vector(data):
                      print("[FileToPDU] Invalid ACK PDU format.")
                      return

                  byte_data = bytearray(pmt.u8vector_elements(data))

                  if len(byte_data) < 2:
                      print("[FileToPDU] ACK PDU too short.")
                      return

                  if byte_data[0] != 0xAA:
                      print("[FileToPDU] Not a valid ACK header.")
                      return

                  pkt_num = byte_data[1]

                  with self._ack_lock:
                      if pkt_num == self._expected_ack:
                          print(f"[FileToPDU] Received PHYSICAL ACK for packet #{pkt_num:02X}")
                          self._ack_event.set()

              except Exception as e:
                  print(f"[FileToPDU] Error handling physical ACK: {str(e)}")
    file_path: |
      r"/home/subodha/Desktop/CDP/FINAL/input.txt"
    interval: '0.1'
    max_packet_size: '32'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '200000'
    center_freq: 442e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '200000'
    center_freq: 432e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_check_0, ok, epy_block_2, ack_bits]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', virtual_sink_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_2, pdus, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [soapy_bladerf_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
