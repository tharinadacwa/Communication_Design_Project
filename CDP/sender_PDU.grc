options:
  parameters:
    author: User
    generate_options: qt_gui
    id: qpskk1111
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os, pmt
      from gnuradio import gr

      try:
          # PyCryptodome
          from Crypto.Cipher import AES
      except ImportError:
          AES = None

      class aes_gcm_encrypt_pdu(gr.basic_block):
          def __init__(self, key_hex="00112233445566778899aabbccddeeff"):
              gr.basic_block.__init__(self,
                  name="AES-GCM Encrypt (PDU)",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.set_msg_handler(pmt.intern("pdus_in"), self._handle)
              self.message_port_register_out(pmt.intern("pdus_out"))

              self.key = bytes.fromhex(key_hex)
              if AES is None:
                  print("[AES-GCM Encrypt] ERROR: PyCryptodome not found. Install with: pip install pycryptodome")

          def _handle(self, msg):
              if AES is None:
                  return
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  print("[AES-GCM Encrypt] Non-u8vector payload")
                  return
              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) == 0:
                  return

              # Keep first byte (seq) in clear; encrypt the rest
              seq = data[0:1]
              plain = bytes(data[1:])

              # 12-byte IV (nonce)
              iv = os.urandom(12)
              cipher = AES.new(self.key, AES.MODE_GCM, nonce=iv)

              # Optionally bind AAD (e.g., sequence byte) so tag covers it
              cipher.update(seq)

              ciphertext, tag = cipher.encrypt_and_digest(plain)

              # Output payload = [seq][IV(12)][ciphertext][tag(16)]
              out = seq + iv + ciphertext + tag
              out_u8 = pmt.init_u8vector(len(out), list(out))
              out_pdu = pmt.cons(meta, out_u8)
              self.message_port_pub(pmt.intern("pdus_out"), out_pdu)
    key_hex: '''00112233445566778899aabbccddeeff'''
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    BitLimiter (fixed byte count):\n    - Wait for tag with name tag_key\n    - When seen, forward exactly packet_bytes bytes\n    \"\"\"\n\n    def __init__(self, tag_key=\"packet_start\", packet_bytes=32):\n        gr.sync_block.__init__(\n            self,\n            name=\"BitLimiterBytes\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8]\n        )\n\n        self.tag_key = pmt.intern(tag_key)\n        self.packet_bytes = int(packet_bytes)\n\n        # State\n        self.active = False\n        self.bytes_remaining = 0\n\n    def work(self, input_items, output_items):\n\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_in = len(inp)\n        out_index = 0\n\n        # ---- Detect tag ----\n        tags = self.get_tags_in_window(0, 0, n_in)\n\n        for t in tags:\n            if t.key == self.tag_key:\n                # Start forwarding packet_bytes bytes\n                self.bytes_remaining = self.packet_bytes\n                self.active = True\n\n        # ---- Forward data ----\n        for i in range(n_in):\n\n            if self.active and self.bytes_remaining > 0:\n                out[out_index] = inp[i]\n                out_index += 1\n                self.bytes_remaining -= 1\n\n                if self.bytes_remaining == 0:\n                    self.active = False\n\n        return out_index\n\n"
    packet_bytes: '8'
    tag_key: '"packet_len"'
  states: {}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):

          def __init__(self, num_bytes=4):
              gr.basic_block.__init__(
                  self,
                  name="PDU Prepend Random Bytes",
                  in_sig=None,
                  out_sig=None
              )

              self.num_bytes = int(num_bytes)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_msg)


          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = pmt.cdr(msg)

              payload = bytes(pmt.u8vector_elements(vec))

              # random bytes
              prepend = np.random.randint(0, 256, self.num_bytes, dtype=np.uint8).tolist()

              # convert payload to list of ints
              payload_list = list(payload)

              # final output list
              out_list = prepend + payload_list

              # convert back to PDU
              out_vec = pmt.init_u8vector(len(out_list), out_list)

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(meta, out_vec)
              )
    num_bytes: '10000'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Idle + Packet Injector
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Continuous stream block with idle bytes 0xAA.
          Injects packets from input stream (Tagged Stream Mux) whenever available.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              print(inp)

              n_out = len(out)
              in_len = len(inp)
              out_index = 0


              # ---- Append input bytes to internal buffer ----
              if in_len > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Fill output ----
              while out_index < n_out:

                  if len(self.packet_buffer) > 0:
                      # Pop from buffer
                      out[out_index] = self.packet_buffer.pop(0)
                  else:
                      # Output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Idle + Packet Injector
          Waits until the full packet (according to header length) is received before transmitting.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []
              self.expected_length = None  # Total packet length including header

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n_out = len(out)
              out_index = 0

              # ---- Append input bytes to internal buffer ----
              if len(inp) > 0:
                  self.packet_buffer.extend(inp.tolist())


              # ---- Extract expected packet length from header ----
              # Header format: XX XX XX XX 00 <length_byte> 00 <length_byte>
              if self.expected_length is None and len(self.packet_buffer) >= 6:
                  length_byte = self.packet_buffer[5]  # 0-based index for first length byte
                  self.expected_length = 8 + length_byte  # 8-byte header + payload

              # ---- Fill output ----
              while out_index < n_out:
                  if self.expected_length is not None and len(self.packet_buffer) >= self.expected_length:
                      # Full packet ready: transmit first byte
                      out[out_index] = self.packet_buffer.pop(0)
                      # If entire packet transmitted, reset expected_length
                      if len(self.packet_buffer) == 0:
                          self.expected_length = None
                  else:
                      # Not enough bytes yet: output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class IdlePacketInjectorWithLength(gr.sync_block):
          """
          Idle + Packet Injector (robust version)
          - Continuously outputs idle bytes until a full packet is buffered.
          - Transmits the entire packet (with payload-length byte first) once ready.
          - Supports back-to-back packets in the buffer.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjectorWithLength",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []
              self.expected_length = None  # total length including header
              self.payload_length = None
              self.send_length_byte = False
              self.sentcount = 0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out_index = 0

              # ---- Append new bytes to internal buffer ----
              if len(inp) > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Process output buffer ----
              while out_index < n_out:

                  # ---- Check if a full packet is available ----
                  if self.expected_length is None and len(self.packet_buffer) >= 6:
                      # Extract payload length from header
                      self.payload_length = self.packet_buffer[5]  # 0-based index
                      self.expected_length = 8 + self.payload_length
                      self.send_length_byte = True
                      self.sentcount = 0

                  # ---- If full packet is ready, transmit it ----
                  if self.expected_length is not None and len(self.packet_buffer) >= self.expected_length:
                      if self.send_length_byte:
                          # Send payload-length byte first
                          out[out_index] = self.payload_length
                          self.send_length_byte = False
                          out_index += 1
                          continue  # continue without incrementing out_index again
                      else:
                          # Send packet bytes
                          out[out_index] = self.packet_buffer.pop(0)
                          print(out[out_index])
                          self.sentcount += 1

                          # Check if packet transmission is complete
                          if self.sentcount >= self.payload_length:
                              # Remove header bytes as well
                              for _ in range(8):
                                  if self.packet_buffer:
                                      self.packet_buffer.pop(0)
                              # Reset state for next packet
                              self.expected_length = None
                              self.payload_length = None
                              self.send_length_byte = False
                              self.sentcount = 0
                  else:
                      # Not enough bytes: send idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Byte-to-PDU including idle
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Convert continuous byte stream (including idle) to PDUs
          """
          def __init__(self, pdu_size=64):
              gr.sync_block.__init__(
                  self,
                  name="ByteToPDUWithIdle",
                  in_sig=[np.uint8],
                  out_sig=[]
              )

              self.message_port_register_out(pmt.intern("pdus"))

              # Buffer to accumulate bytes before creating PDU
              self.byte_buffer = []

              # How many bytes per PDU
              self.pdu_size = int(pdu_size)

          def work(self, input_items, output_items):
              inp = input_items[0]
              n_in = len(inp)

              # Append all incoming bytes (idle + packets) to buffer
              self.byte_buffer.extend(inp.tolist())


              # Emit PDUs whenever buffer has enough bytes
              while len(self.byte_buffer) >= self.pdu_size:
                  pdu_bytes = self.byte_buffer[:self.pdu_size]
                  self.byte_buffer = self.byte_buffer[self.pdu_size:]

                  # Create PMT vector
                  pdu = pmt.init_u8vector(len(pdu_bytes), pdu_bytes)
                  # Send PDU
                  self.message_port_pub(pmt.intern("pdus"), pmt.cons(pmt.PMT_NIL, pdu))
                  print("I SENT IT")

              return n_in
    pdu_size: '32'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class dump_hex(gr.sync_block):
          """
          Prints bytes in hex format.
          """
          def __init__(self, label="HEX"):
              gr.sync_block.__init__(
                  self,
                  name="DumpHex",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.label = label

          def work(self, input_items, output_items):
              inp = input_items[0]

              hex_str = " ".join([f"{b:02X}" for b in inp])
              print(f"{self.label}: {hex_str}")

              return len(inp)
    label: '''HEX'''
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from collections import deque

      class IdlePacketInjectorExact(gr.sync_block):
          """
          IdlePacketInjectorExact
          - Idle byte (0xAA) is output continuously until a full packet is buffered.
          - Packet format expected in rx stream: 8-byte header (header[5] = payload_len) followed by payload_len bytes.
          - When full packet is available, transmit exactly:
               [header0..7][payload_len][payload_bytes]
            (i.e., transmit the packet exactly as received)
          - Transmission is continuous at the normal flow rate; packets may span multiple work() calls.
          - While transmitting a packet, rx_buf continues to accumulate the next incoming packet.
          """

          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjectorExact",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte & 0xFF

              # rx_buf: collects incoming raw bytes (deque for O(1) pops/appends)
              self.rx_buf = deque()
              # tx_buf: bytes of the packet currently being transmitted (deque)
              self.tx_buf = deque()

              # state helpers
              self.waiting_for_full_packet = True  # True when looking to form next tx_buf from rx_buf

          def _try_make_packet(self):
              """
              If rx_buf contains at least 8 bytes, read header[5] to get payload length,
              and if rx_buf contains the full packet (8 + payload_len), move those bytes
              to tx_buf (only if tx_buf is currently empty so we keep single active tx buffer).
              """
              # Only create a new tx packet if nothing is currently transmitting
              if self.tx_buf:
                  return

              # Need at least 6 bytes to read header[5] safely (indexes 0..5)
              if len(self.rx_buf) < 6:
                  return

              # Peek header[5] without popping
              # Convert deque to indexing by iterating - deque supports indexing but it's O(n).
              # Access small index directly via tuple() for efficiency when len small
              # but for clarity just use indexing (acceptable because index 5).
              payload_len = self.rx_buf[5]

              total_len = 8 + int(payload_len)  # 8-byte header + payload_len bytes

              # If we have full packet in rx_buf, move it to tx_buf
              if len(self.rx_buf) >= total_len:
                  # move the first total_len bytes from rx_buf to tx_buf in order
                  for _ in range(total_len):
                      self.tx_buf.append(self.rx_buf.popleft())

                  # Now tx_buf contains [header0..7, payload...], and will be transmitted
                  # We don't set any special flag; presence of tx_buf indicates active transmission

      # assume total_len = header_len + payload_len
                  #header = [self.rx_buf.popleft() for _ in range(8)]  # first 8 bytes of header
                  #payload = [self.rx_buf.popleft() for _ in range(total_len - 8)]  # rest of packet

      # insert payload length byte right after header
                  #payload_len_byte = total_len - 8
                  #self.tx_buf.extend(header)         # header bytes
                  #self.tx_buf.append(payload_len)  # length byte
                  #self.tx_buf.extend(payload)        # payload bytes
                  #print(self.tx_buf)


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out_index = 0

              # 1) append incoming bytes to rx_buf
              if len(inp) > 0:
                  # inp is a numpy array of uint8
                  self.rx_buf.extend(int(b) for b in inp.tolist())

              # 2) if no active tx_buf, try to assemble a packet from rx_buf
              # This also ensures back-to-back packets are handled: after finishing one,
              # next will be immediately prepared if rx_buf already contains it.
              self._try_make_packet()

              # 3) fill the output buffer at full rate.
              #    If tx_buf has data -> stream it continuously until empty,
              #    otherwise send idle bytes.
              while out_index < n_out:
                  if self.tx_buf:
                      # transmit next byte of current packet
                      out[out_index] = self.tx_buf.popleft()
                      out_index += 1

                      # after popping a byte, if tx_buf becomes empty, attempt to prepare next packet
                      if not self.tx_buf:
                          # attempt to build the next packet immediately (back-to-back)
                          self._try_make_packet()
                      # continue loop
                  else:
                      # no packet currently being transmitted -> output idle
                      out[out_index] = self.idle_byte
                      out_index += 1

                      # also after sending idle we can check if rx_buf now contains a full packet
                      # (useful if rx_buf filled during this work() call)
                      # But avoid calling _try_make_packet too often; it's cheap so ok:
                      self._try_make_packet()

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import datetime

      class MessageBubble(QtWidgets.QWidget):
          """A custom widget to render a message bubble"""
          def __init__(self, text, time_str, status="Waiting", parent=None):
              super().__init__(parent)
              self.layout = QtWidgets.QHBoxLayout()
              self.layout.setContentsMargins(0, 5, 0, 5)

              self.container = QtWidgets.QFrame()
              self.container_layout = QtWidgets.QVBoxLayout()
              self.container.setLayout(self.container_layout)
              
              self.container.setStyleSheet("""
                  QFrame {
                      background-color: #EEFFDD; 
                      border-radius: 10px;
                      border: 1px solid #CCDDCC;
                  }
              """)

              self.lbl_text = QtWidgets.QLabel(text)
              self.lbl_text.setWordWrap(True)
              self.lbl_text.setStyleSheet("border: none; font-size: 14px; color: black;")
              self.container_layout.addWidget(self.lbl_text)

              self.meta_layout = QtWidgets.QHBoxLayout()
              self.lbl_time = QtWidgets.QLabel(time_str)
              self.lbl_time.setStyleSheet("border: none; font-size: 10px; color: #555;")
              
              self.lbl_status = QtWidgets.QLabel(status)
              self.lbl_status.setStyleSheet("border: none; font-size: 10px; font-weight: bold; color: gray;")
              
              self.meta_layout.addStretch()
              self.meta_layout.addWidget(self.lbl_time)
              self.meta_layout.addWidget(self.lbl_status)
              self.container_layout.addLayout(self.meta_layout)

              self.layout.addStretch()
              self.layout.addWidget(self.container)
              self.setLayout(self.layout)

          def set_status(self, status, color):
              self.lbl_status.setText(status)
              self.lbl_status.setStyleSheet(f"border: none; font-size: 10px; font-weight: bold; color: {color};")
              if status == "Failed":
                   self.container.setStyleSheet("QFrame { background-color: #FFDDDD; border-radius: 10px; border: 1px solid #DDAAAA; }")
              elif "Sent" in status:
                   self.container.setStyleSheet("QFrame { background-color: #EEFFDD; border-radius: 10px; border: 1px solid #CCDDCC; }")

      class ChatWindow(QtWidgets.QWidget):
          """The Telegram-style Window"""
          send_signal = QtCore.pyqtSignal(str)
          # NEW: Internal signal for thread-safe updates
          status_signal = QtCore.pyqtSignal(str, str) 

          def __init__(self):
              super().__init__()
              self.setWindowTitle("Secure Radio Chat")
              self.resize(400, 600)
              self.setStyleSheet("background-color: #E6EBEF;")

              layout = QtWidgets.QVBoxLayout()

              self.chat_area = QtWidgets.QListWidget()
              self.chat_area.setStyleSheet("border: none; background-color: transparent;")
              self.chat_area.setSelectionMode(QtWidgets.QAbstractItemView.NoSelection)
              self.chat_area.setVerticalScrollMode(QtWidgets.QAbstractItemView.ScrollPerPixel)
              layout.addWidget(self.chat_area)

              input_container = QtWidgets.QWidget()
              input_container.setStyleSheet("background-color: white; border-top: 1px solid #DDD;")
              input_layout = QtWidgets.QHBoxLayout()
              input_container.setLayout(input_layout)

              self.text_input = QtWidgets.QLineEdit()
              self.text_input.setPlaceholderText("Write a message...")
              self.text_input.returnPressed.connect(self.on_send)
              input_layout.addWidget(self.text_input)

              self.send_btn = QtWidgets.QPushButton("➤") 
              self.send_btn.setFixedSize(40, 40)
              self.send_btn.setStyleSheet("background-color: #3390EC; color: white; border-radius: 20px; font-weight: bold;")
              self.send_btn.clicked.connect(self.on_send)
              input_layout.addWidget(self.send_btn)

              layout.addWidget(input_container)
              self.setLayout(layout)

              self.current_bubble = None
              
              # Connect the signal to the update function
              self.status_signal.connect(self.update_last_status)

          def on_send(self):
              text = self.text_input.text().strip()
              if text:
                  self.text_input.clear()
                  time_str = datetime.datetime.now().strftime("%H:%M")
                  self.current_bubble = MessageBubble(text, time_str, "Sending...")
                  
                  item = QtWidgets.QListWidgetItem()
                  item.setSizeHint(self.current_bubble.sizeHint())
                  self.chat_area.addItem(item)
                  self.chat_area.setItemWidget(item, self.current_bubble)
                  self.chat_area.scrollToBottom()

                  self.send_signal.emit(text)

          def update_last_status(self, text, color):
              if self.current_bubble:
                  self.current_bubble.set_status(text, color)

      class ChatInterface(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Chat Interface (Telegram Style)",
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern("msg_out"))
              self.message_port_register_in(pmt.intern("status_in"))
              self.set_msg_handler(pmt.intern("status_in"), self.handle_status)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.gui = ChatWindow()
              self.gui.send_signal.connect(self.send_message)
              self.gui.show()

          def send_message(self, text):
              msg = pmt.intern(text)
              self.message_port_pub(pmt.intern("msg_out"), msg)

          def handle_status(self, msg):
              """Receives status updates from Block 2"""
              try:
                  status_str = pmt.symbol_to_string(msg)
                  
                  # DEBUG PRINT: Check if this appears in your GRC console!
                  print(f"[GUI] Status received: '{status_str}'")

                  if status_str == "success":
                      # Use signal to update GUI safely
                      self.gui.status_signal.emit("✓ Sent", "#3390EC")
                  elif status_str == "fail":
                      self.gui.status_signal.emit("Failed", "red")
                  elif status_str == "pending":
                      pass

              except Exception as e:
                  print(f"[GUI] Error handling status: {e}")

          def stop(self):
              self.gui.close()
              return super().stop()
  states: {}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class blk(gr.basic_block):  # Inherit from basic_block for Message passing
          """Text to PDU (Blind Repeater) - Interval in Seconds"""

          def __init__(self, preamble_len=100, repeat_count=5, repeat_interval_seconds=1.0, src_address=1, dest_address=2):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Text to PDU (Blind Repeater)',   # will show up in GRC
                  in_sig=None,   # No streaming inputs
                  out_sig=None   # No streaming outputs
              )
              
              # --- Parameters ---
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              
              # This value is treated as SECONDS (e.g., 1.0 = 1 second, 0.5 = 500ms)
              self.repeat_interval = float(repeat_interval_seconds) 
              
              self.src_address = int(src_address) & 0xFF
              self.dest_address = int(dest_address) & 0xFF

              # --- Message Ports ---
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_input)

              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("status_out"))

              # Threading lock
              self._tx_lock = threading.Lock()

          def handle_msg_input(self, msg):
              """Handler for incoming text messages from GUI"""
              try:
                  text_data = pmt.symbol_to_string(msg)
              except:
                  print("[BlindTx] Error: Input must be a string symbol")
                  return

              if self._tx_lock.locked():
                  print("[BlindTx] Busy sending previous message.")
                  return

              t = threading.Thread(target=self._process_transmission, args=(text_data,))
              t.daemon = True
              t.start()

          def _process_transmission(self, text_data):
              """Constructs packet and repeats it with user-defined interval in seconds"""
              with self._tx_lock:
                  # Update GUI status
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("pending"))
                  
                  # --- CONSTRUCT THE PACKET ---
                  preamble = bytes([0xAA] * self.preamble_len)
                  header = bytes([self.src_address, self.dest_address, 0x01])
                  payload = text_data.encode('utf-8')
                  
                  full_data = preamble + header + payload
                  
                  pdu_vector = pmt.init_u8vector(len(full_data), list(full_data))
                  pdu = pmt.cons(pmt.make_dict(), pdu_vector)

                  print(f"[BlindTx] Sending {len(full_data)} bytes. Repeats: {self.repeat_count}, Interval: {self.repeat_interval}s")

                  # --- SEND LOOP ---
                  for i in range(self.repeat_count):
                      self.message_port_pub(pmt.intern("pdus"), pdu)
                      
                      # Sleep in SECONDS
                      time.sleep(self.repeat_interval)

                  # Update GUI status
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("success"))
                  print("[BlindTx] Done.")

          def work(self, input_items, output_items):
              """Not used for Message Blocks"""
              return 0
    dest_address: '2'
    preamble_len: '1000'
    repeat_count: '1000'
    repeat_interval_seconds: '0.1'
    src_address: '1'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq2
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freq1
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ack
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ack
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_repack_bits_bb_1_0_0, '0', epy_block_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3_1, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_6, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_check_0, ok, virtual_sink_2, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', virtual_sink_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_async_0, header, epy_block_10, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, blocks_message_debug_0, log]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0, pdus_out, digital_crc_append_0, in]
- [epy_block_1, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [epy_block_10, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_3, '0', digital_constellation_modulator_0, '0']
- [epy_block_3, '0', epy_block_5, '0']
- [epy_block_3_0, '0', digital_constellation_modulator_0, '0']
- [epy_block_3_0, '0', epy_block_5, '0']
- [epy_block_3_1, '0', digital_constellation_modulator_0, '0']
- [epy_block_3_1, '0', epy_block_5, '0']
- [epy_block_6, '0', digital_constellation_modulator_0, '0']
- [epy_block_6, '0', epy_block_5, '0']
- [epy_block_8, msg_out, blocks_message_debug_0_0, log]
- [epy_block_8, msg_out, epy_block_9, msg_in]
- [epy_block_9, pdus, digital_crc_append_0, in]
- [epy_block_9, status_out, epy_block_8, status_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [soapy_bladerf_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
