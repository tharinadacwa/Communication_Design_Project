options:
  parameters:
    author: User
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: equalizer
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '15'
    step: '1'
    stop: '100'
    value: '15'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '"010101010111000100"'
    bps: '2'
    threshold: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: equalizer
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.4'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr
      import os

      class blk(gr.basic_block):
          # USE r"" for Windows paths to handle backslashes correctly
          def __init__(self, file_path=r"C:\Users\Subodha\Desktop\CDP\output.txt", append=False):
              gr.basic_block.__init__(
                  self,
                  name="pdu_file_writer",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.append = append

              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_pdu)

              # LOGIC FIX: Only wipe the file if we are NOT in append mode
              if not self.append:
                  # "wb" opens for writing and deletes existing content
                  try:
                      open(self.file_path, "wb").close()
                  except Exception as e:
                      print(f"Error initializing file: {e}")

          def handle_pdu(self, msg):
              # Extract data from PDU (pair: meta . data)
              # meta = pmt.car(msg) # Metadata (not used here)
              data = pmt.cdr(msg)   # The actual bytes

              if pmt.is_u8vector(data):
                  byte_data = bytes(pmt.u8vector_elements(data))

                  # ALWAYS use "ab" (Append Binary) here.
                  # Why? Because if you use "wb", packet #2 will delete packet #1.
                  # We want to add to the file *during* this run.
                  try:
                      with open(self.file_path, "ab") as f:
                          f.write(byte_data)
                          f.flush() # Ensure data is written to disk immediately
                  except Exception as e:
                      print(f"Error writing to file: {e}")
    append: 'True'
    file_path: r"C:\Users\Subodha\Desktop\CDP\output.txt"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      try:
          from Crypto.Cipher import AES
      except ImportError:
          AES = None

      class aes_gcm_decrypt_pdu(gr.basic_block):
          def __init__(self, key_hex="00112233445566778899aabbccddeeff"):
              gr.basic_block.__init__(self,
                  name="AES-GCM Decrypt (PDU)",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.set_msg_handler(pmt.intern("pdus_in"), self._handle)
              self.message_port_register_out(pmt.intern("pdus_out"))

              self.key = bytes.fromhex(key_hex)
              if AES is None:
                  print("[AES-GCM Decrypt] ERROR: PyCryptodome not found. Install with: pip install pycryptodome")

          def _handle(self, msg):
              if AES is None:
                  return
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  print("[AES-GCM Decrypt] Non-u8vector payload")
                  return
              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) < 1 + 12 + 16:
                  print("[AES-GCM Decrypt] Frame too short")
                  return

              seq = bytes([data[0]])
              iv  = bytes(data[1:1+12])
              tag = bytes(data[-16:])
              ciphertext = bytes(data[1+12:-16])

              try:
                  cipher = AES.new(self.key, AES.MODE_GCM, nonce=iv)
                  cipher.update(seq)  # must match encrypt side
                  plain = cipher.decrypt_and_verify(ciphertext, tag)
              except Exception as e:
                  print(f"[AES-GCM Decrypt] Auth failed: {e}")
                  return  # drop corrupted/forged frame

              # Rebuild original PDU payload: [seq][plaintext]
              out = seq + plain
              out_u8 = pmt.init_u8vector(len(out), list(out))
              out_pdu = pmt.cons(meta, out_u8)
              self.message_port_pub(pmt.intern("pdus_out"), out_pdu)
    key_hex: '''00112233445566778899aabbccddeeff'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          BitLimiter (fixed byte count):
          - Wait for tag with name tag_key
          - When seen, forward exactly packet_bytes bytes
          """

          def __init__(self, tag_key="packet_start", packet_bytes=32):
              gr.sync_block.__init__(
                  self,
                  name="BitLimiterBytes",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_key)
              self.packet_bytes = int(packet_bytes)

              # State
              self.active = False
              self.bytes_remaining = 0

          def work(self, input_items, output_items):

              inp = input_items[0]
              out = output_items[0]

              n_in = len(inp)
              out_index = 0

              # ---- Detect tag ----
              tags = self.get_tags_in_window(0, 0, n_in)

              for t in tags:
                  if t.key == self.tag_key:
                      # Start forwarding packet_bytes bytes
                      self.bytes_remaining = self.packet_bytes
                      self.active = True

              # ---- Forward data ----
              for i in range(n_in):

                  if self.active and self.bytes_remaining > 0:
                      out[out_index] = inp[i]
                      out_index += 1
                      self.bytes_remaining -= 1

                      if self.bytes_remaining == 0:
                          self.active = False

              return out_index
    packet_bytes: '53'
    tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, address=1, max_packet_size=32):  # Receiver address + packet size
              gr.basic_block.__init__(
                  self,
                  name="pdu_deduplicator",
                  in_sig=[],
                  out_sig=[]
              )

              self.address = int(address) & 0xFF
              self.max_packet_size = int(max_packet_size)

              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_out(pmt.intern("ack_packet_out"))

              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_pdu)

              self.seen_packets = set()

          def reset_sequence(self):
              """Resets deduplication state after receiving termination packet."""
              print("[Deduplicator] Resetting sequence state.")
              self.seen_packets = set()

          def handle_pdu(self, msg):

              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  print("[Deduplicator] Invalid data type.")
                  return

              byte_data = bytearray(pmt.u8vector_elements(data))

              if len(byte_data) < 3:
                  print("[Deduplicator] Packet too short.")
                  return

              src_addr = byte_data[0]
              dest_addr = byte_data[1]
              pkt_num = byte_data[2]

              # Only accept packets addressed to me
              if dest_addr != self.address:
                  return

              # ---------------------------------------------------------
              #  CHECK FOR TERMINATION PACKET
              # ---------------------------------------------------------
              expected_term_length = self.max_packet_size + 1

              if len(byte_data) == expected_term_length:
                  # termination payload = all 0xFF bytes
                  payload = byte_data[3:]
                  if all(b == 0xFF for b in payload):

                      print(f"[Deduplicator] Termination packet #{pkt_num:02X} received. Sending ACK & resetting.")

                      # Send ACK (same mechanism as normal)
                      ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])
                      ack_pdu = pmt.cons(pmt.make_dict(),
                                         pmt.init_u8vector(len(ack_packet), list(ack_packet)))

                      for _ in range(80):
                          self.message_port_pub(pmt.intern("ack_packet_out"), ack_pdu)

                      # Reset deduplication for next message
                      self.reset_sequence()

                      # DO NOT forward termination packet
                      return

              # ---------------------------------------------------------
              #  NORMAL PACKET HANDLING
              # ---------------------------------------------------------

              # Duplicate check
              if pkt_num in self.seen_packets:
                  print(f"[Deduplicator] Duplicate packet #{pkt_num:02X} discarded.")
                  return

              self.seen_packets.add(pkt_num)

              # Forward stripped payload (remove src,dest,pktnum)
              stripped_payload = byte_data[3:]
              payload = pmt.init_u8vector(len(stripped_payload), list(stripped_payload))
              pdu = pmt.cons(pmt.make_dict(), payload)
              self.message_port_pub(pmt.intern("pdus_out"), pdu)

              # Send ACK
              ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])
              ack_pdu = pmt.cons(pmt.make_dict(),
                                 pmt.init_u8vector(len(ack_packet), list(ack_packet)))

              print("[Deduplicator] Sending ACK...")
              for _ in range(80):
                  self.message_port_pub(pmt.intern("ack_packet_out"), ack_pdu)

              print(f"[Deduplicator] Accepted packet #{pkt_num:02X} from {src_addr:02X}. Sent ACK.")
    address: '2'
    max_packet_size: '32'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Idle + Packet Injector
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Continuous stream block with idle bytes 0xAA.
          Injects packets from input stream (Tagged Stream Mux) whenever available.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n_out = len(out)
              in_len = len(inp)
              out_index = 0

              # ---- Append input bytes to internal buffer ----
              if in_len > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Fill output ----
              while out_index < n_out:

                  if len(self.packet_buffer) > 0:
                      # Pop from buffer
                      out[out_index] = self.packet_buffer.pop(0)
                  else:
                      # Output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class TaggedPayloadExtractor(gr.sync_block):
          """
          Tag-based payload extractor.
          - Waits for a tag with name `tag_key`.
          - Reads the first byte after the tag as payload length.
          - Forwards exactly that many bytes.
          - Discards anything else until next tag.
          """
          def __init__(self, tag_key="packet_start"):
              gr.sync_block.__init__(
                  self,
                  name="TaggedPayloadExtractor",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_key)
              self.active = False
              self.bytes_remaining = 0
              self.length_byte_read = False


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)
              out_index = 0
              consumed = 0

              print(inp)

              # ---- Check for tags in current window ----
              tags = self.get_tags_in_window(0, 0, n_in)
              for t in tags:
                  if t.key == self.tag_key:
                      self.active = True
                      self.bytes_remaining = 0
                      self.length_byte_read = False

              # ---- Process input bytes ----
              for i in range(n_in):
                  if self.active:
                      if not self.length_byte_read:
                          # First byte after tag = payload length
                          self.bytes_remaining = inp[i]
                          self.length_byte_read = True
                          consumed+=1


                      elif self.bytes_remaining > 0:
                          if out_index < len(out):
                              out[out_index] = inp[i]
                              out_index += 1
                              consumed+=1
                              self.bytes_remaining -= 1
                              if self.bytes_remaining == 0:
                                  # Packet done, wait for next tag
                                  self.active = False
                                  self.length_byte_read = False

              return consumed
              #return n_in
    tag_key: '''packet_len'''
  states: {state: disabled}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class dump_hex(gr.sync_block):
          """
          Prints bytes in hex format.
          """
          def __init__(self, label="HEX"):
              gr.sync_block.__init__(
                  self,
                  name="DumpHex",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.label = label

          def work(self, input_items, output_items):
              inp = input_items[0]

              hex_str = " ".join([f"{b:02X}" for b in inp])
              print(f"{self.label}: {hex_str}")

              return len(inp)
    label: '''HEX'''
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    size: '20'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq2
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freq1
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', epy_block_2, '0']
- [blocks_repack_bits_bb_1_0_0, '0', epy_block_5, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_4, '0']
- [blocks_throttle2_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_throttle2_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', epy_block_5_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_check_0, ok, blocks_message_debug_1, log]
- [digital_crc_check_0, ok, epy_block_1, pdus_in]
- [digital_crc_check_0, ok, epy_block_3, pdus_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_1, pdus_out, epy_block_3, pdus_in]
- [epy_block_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [epy_block_3, ack_packet_out, digital_crc_append_0, in]
- [epy_block_3, pdus_out, epy_block_0, pdus]
- [epy_block_4, '0', digital_constellation_modulator_0, '0']
- [epy_block_5, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0, log]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
