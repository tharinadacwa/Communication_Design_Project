options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import os

      class blk(gr.sync_block):
          """Reads text file and outputs ASCII bits as floats"""

          def __init__(self, filename="text.txt"):
              gr.sync_block.__init__(
                  self,
                  name='Text to Bits Block',
                  in_sig=[],
                  out_sig=[np.float32]  # output as float
              )
              self.filename = filename
              self.bits = None
              self.index = 0

          def _load_bits(self):
              if self.bits is None:
                  if not os.path.exists(self.filename):
                      # If missing, just output "EMPTY"
                      text = "EMPTY"
                  else:
                      with open(self.filename, "r") as f:
                          text = f.read().strip()

                  # Convert text to ASCII bits as floats
                  self.bits = np.array(
                      [float(b) for c in text for b in f"{ord(c):08b}"],
                      dtype=np.float32
                  )

          def work(self, input_items, output_items):
              self._load_bits()
              out = output_items[0]
              n = len(out)

              for i in range(n):
                  out[i] = self.bits[self.index]
                  self.index = (self.index + 1) % len(self.bits)

              return n
    filename: '''text.txt'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
