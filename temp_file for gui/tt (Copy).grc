options:
  parameters:
    author: User
    generate_options: qt_gui
    id: srnew
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: equalizer
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '15'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: freq1_0
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq2_0
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: phase_bw_0
  id: variable
  parameters:
    value: '0.0628'
  states: {state: disabled}
- name: phase_bw_0
  id: variable_qtgui_range
  parameters:
    start: '10.8e-3'
    step: '0.5e-3'
    stop: '100.8e-3'
    value: '50e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: thresh_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: thresh_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_adaptive_algorithm_0_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '"010101010111000100"'
    bps: '2'
    threshold: '2'
  states: {}
- name: variable_header_format_default_0_0
  id: variable_header_format_default
  parameters:
    access_code: '"010101010111000100"'
    bps: '2'
    threshold: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_3
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_4
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: '300e-3'
    seed: '0'
    taps: '3'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: '300e-3'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: equalizer
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os, pmt
      from gnuradio import gr

      try:
          # PyCryptodome
          from Crypto.Cipher import AES
      except ImportError:
          AES = None

      class aes_gcm_encrypt_pdu(gr.basic_block):
          def __init__(self, key_hex="00112233445566778899aabbccddeeff"):
              gr.basic_block.__init__(self,
                  name="AES-GCM Encrypt (PDU)",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.set_msg_handler(pmt.intern("pdus_in"), self._handle)
              self.message_port_register_out(pmt.intern("pdus_out"))

              self.key = bytes.fromhex(key_hex)
              if AES is None:
                  print("[AES-GCM Encrypt] ERROR: PyCryptodome not found. Install with: pip install pycryptodome")

          def _handle(self, msg):
              if AES is None:
                  return
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  print("[AES-GCM Encrypt] Non-u8vector payload")
                  return
              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) == 0:
                  return

              # Keep first byte (seq) in clear; encrypt the rest
              seq = data[0:1]
              plain = bytes(data[1:])

              # 12-byte IV (nonce)
              iv = os.urandom(12)
              cipher = AES.new(self.key, AES.MODE_GCM, nonce=iv)

              # Optionally bind AAD (e.g., sequence byte) so tag covers it
              cipher.update(seq)

              ciphertext, tag = cipher.encrypt_and_digest(plain)

              # Output payload = [seq][IV(12)][ciphertext][tag(16)]
              out = seq + iv + ciphertext + tag
              out_u8 = pmt.init_u8vector(len(out), list(out))
              out_pdu = pmt.cons(meta, out_u8)
              self.message_port_pub(pmt.intern("pdus_out"), out_pdu)
    key_hex: '''00112233445566778899aabbccddeeff'''
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, file_path="/home/subodha/Downloads/output.tmp", append=False):
              gr.basic_block.__init__(
                  self,
                  name="pdu_file_writer",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.append = append  # If True, append to file; else overwrite

              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_pdu)

              # If overwrite mode, clear the file at the start

              open(self.file_path, "wb").close()

          def handle_pdu(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if pmt.is_u8vector(data):
                  byte_data = bytes(pmt.u8vector_elements(data))

                  # Determine file mode: append ("ab") or write ("wb")
                  mode = "ab" if self.append else "ab"  # still append for multiple PDUs in same run

                  with open(self.file_path, mode) as f:
                      f.write(byte_data)
    append: 'True'
    file_path: r"/home/subodha/Downloads/output.tmp"
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend a dynamic address byte to a PDU payload.
          
          This block has no GRC parameters. It relies entirely on the 'addr_in' 
          port to set the destination address.
          """
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              # Default internal state (will be overwritten by GUI immediately)
              self.address = 0x00
              
              # Port for the Text Payload
              self.message_port_register_in(pmt.intern("in"))
              # Port for the Address Update
              self.message_port_register_in(pmt.intern("addr_in"))
              
              # Output Port
              self.message_port_register_out(pmt.intern("out"))
              
              # Register handlers
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.set_msg_handler(pmt.intern("addr_in"), self.handle_address_update)

          def handle_address_update(self, msg):
              """
              Receives the address from the GUI (Symbol or Int) 
              and updates the internal state.
              """
              try:
                  # GUI sends address as a String Symbol (e.g. "255")
                  if pmt.is_symbol(msg):
                      str_val = pmt.symbol_to_string(msg)
                      self.address = int(str_val)
                  
                  # If standard int/long is sent
                  elif pmt.is_integer(msg) or pmt.is_uint64(msg):
                      self.address = pmt.to_long(msg)
                      
                  # print(f"[address_add] Active Address set to: {self.address}")
                      
              except ValueError:
                  pass

          def handle_msg(self, msg):
              """
              Prepend the currently active 'self.address' to the message.
              """
              meta = pmt.make_dict()
              payload = bytearray()

              # 1. Parse Input
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  payload = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
              elif pmt.is_symbol(msg):
                  text_data = pmt.symbol_to_string(msg)
                  payload = bytearray(text_data, 'utf-8')
              else:
                  return

              # 2. Prepend Address
              safe_addr = self.address & 0xFF
              payload.insert(0, safe_addr)

              # 3. Publish
              out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
              self.message_port_pub(pmt.intern("out"), out_msg)
  states: {state: disabled}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      # ==========================================
      # 1. CUSTOM UI COMPONENTS
      # ==========================================

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap and not self.bg_pixmap.isNull():
                  painter = QtGui.QPainter(self.viewport())
                  scaled_pixmap = self.bg_pixmap.scaled(
                      self.viewport().size(),
                      QtCore.Qt.KeepAspectRatioByExpanding,
                      QtCore.Qt.SmoothTransformation
                  )
                  x = (self.viewport().width() - scaled_pixmap.width()) // 2
                  y = (self.viewport().height() - scaled_pixmap.height()) // 2
                  painter.drawPixmap(x, y, scaled_pixmap)
              super().paintEvent(event)

      # ==========================================
      # 2. THE MAIN WINDOW (GUI LOGIC)
      # ==========================================
      class MessengerWindow(QtWidgets.QWidget):
          # Signals to GR
          send_to_gr_signal = QtCore.pyqtSignal(str)
          addr_selected_signal = QtCore.pyqtSignal(str)

          def __init__(self, bg_image=""):
              super().__init__()
              self.setWindowTitle("BellLabz")
              self.resize(950, 700)
              self.bg_image_path = bg_image
              
              # --- STATE FLAGS ---
              self.is_waiting_for_ack = False 
              
              # --- DATA STRUCTURES ---
              self.added_addresses = set()
              self.selected_btn = None 
              self.current_dest_address = None
              
              # Structure: { addr_int: {'page': widget, 'layout': box, 'scroll': area, 'btn': btn_obj, 'dot': dot_label} }
              self.user_data = {} 

              # --- STYLES ---
              self.style_btn_normal = """
                  QPushButton {
                      background-color: #34495e; color: #ecf0f1; border: 1px solid #2c3e50;
                      padding: 12px; border-radius: 6px; text-align: left;
                  }
                  QPushButton:hover { background-color: #4b6584; }
                  QPushButton:disabled { background-color: #2c3e50; color: #7f8c8d; border: 1px solid #2c3e50; }
              """
              self.style_btn_selected = """
                  QPushButton {
                      background-color: #27ae60; color: white; border: 2px solid white;
                      padding: 12px; border-radius: 6px; text-align: left; font-weight: bold;
                  }
                  QPushButton:disabled { background-color: #2ecc71; opacity: 0.7; }
              """

              # --- MAIN LAYOUT ---
              self.main_layout = QtWidgets.QHBoxLayout()
              self.main_layout.setContentsMargins(0, 0, 0, 0)
              self.main_layout.setSpacing(0)
              self.setLayout(self.main_layout)

              self._init_sidebar()
              self._init_right_panel()

          def _init_sidebar(self):
              self.sidebar = QtWidgets.QWidget()
              self.sidebar.setFixedWidth(250)
              self.sidebar.setStyleSheet("background-color: #2c3e50; border-right: 1px solid #1a252f;")
              layout = QtWidgets.QVBoxLayout(self.sidebar)
              layout.setSpacing(10)

              header = QtWidgets.QLabel("CHATS")
              header.setStyleSheet("color: #95a5a6; font-weight: bold; margin-top: 10px; font-size: 14px;")
              layout.addWidget(header)

              # Input
              input_con = QtWidgets.QHBoxLayout()
              self.addr_input = QtWidgets.QLineEdit()
              self.addr_input.setPlaceholderText("ID (0-255)")
              self.addr_input.setStyleSheet("""
                  QLineEdit { background: #ecf0f1; border: none; border-radius: 4px; padding: 8px; color: black; }
                  QLineEdit:disabled { background: #95a5a6; color: #555; }
              """)
              self.addr_input.setValidator(QtGui.QIntValidator(0, 255))
              self.addr_input.returnPressed.connect(self.manual_add_address)

              self.add_btn = QtWidgets.QPushButton("+")
              self.add_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.add_btn.setFixedWidth(40)
              self.add_btn.clicked.connect(self.manual_add_address)
              self.add_btn.setStyleSheet("""
                  QPushButton { background: #3498db; color: white; border: none; border-radius: 4px; font-weight: bold; }
                  QPushButton:disabled { background: #7f8c8d; }
              """)
              
              input_con.addWidget(self.addr_input)
              input_con.addWidget(self.add_btn)
              layout.addLayout(input_con)

              layout.addWidget(self._create_separator())

              # Contact List Scroll
              self.contact_scroll = QtWidgets.QScrollArea()
              self.contact_scroll.setWidgetResizable(True)
              self.contact_scroll.setStyleSheet("border: none; background: transparent;")
              
              self.contact_container = QtWidgets.QWidget()
              self.contact_layout = QtWidgets.QVBoxLayout(self.contact_container)
              self.contact_layout.setAlignment(QtCore.Qt.AlignTop)
              self.contact_layout.setSpacing(5)
              self.contact_scroll.setWidget(self.contact_container)

              layout.addWidget(self.contact_scroll)
              self.main_layout.addWidget(self.sidebar)

          def _init_right_panel(self):
              right_panel = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(right_panel)
              layout.setContentsMargins(0, 0, 0, 0)
              layout.setSpacing(0)

              # Stack for Chat Pages
              self.chat_stack = QtWidgets.QStackedWidget()
              welcome_page = QtWidgets.QLabel("Select a contact to start messaging")
              welcome_page.setAlignment(QtCore.Qt.AlignCenter)
              welcome_page.setStyleSheet("background-color: #e5ddd5; color: #888; font-size: 18px;")
              self.chat_stack.addWidget(welcome_page)
              layout.addWidget(self.chat_stack, stretch=1)

              # Input Area
              self.input_box_wrapper = QtWidgets.QWidget()
              self.input_box_wrapper.setStyleSheet("background-color: #f0f0f0; border-top: 1px solid #dcdcdc;")
              input_box_layout = QtWidgets.QHBoxLayout(self.input_box_wrapper)
              input_box_layout.setContentsMargins(10, 10, 10, 10)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message...")
              self.msg_input.setStyleSheet("""
                  QLineEdit { border-radius: 20px; padding: 10px 15px; background: white; border: 1px solid #ccc; font-size: 14px; }
                  QLineEdit:disabled { background-color: #e0e0e0; color: #888; }
              """)
              
              self.send_btn = QtWidgets.QPushButton("Send")
              self.send_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.send_btn.setStyleSheet("""
                  QPushButton { background-color: #008069; color: white; border-radius: 20px; padding: 10px 20px; font-weight: bold; }
                  QPushButton:disabled { background-color: #95a5a6; }
              """)
              
              self.msg_input.returnPressed.connect(self.on_send_click)
              self.send_btn.clicked.connect(self.on_send_click)

              input_box_layout.addWidget(self.msg_input)
              input_box_layout.addWidget(self.send_btn)

              layout.addWidget(self.input_box_wrapper)
              self.main_layout.addWidget(right_panel)
              
              self.input_box_wrapper.hide()

          def _create_separator(self):
              line = QtWidgets.QFrame()
              line.setFrameShape(QtWidgets.QFrame.HLine)
              line.setStyleSheet("color: #3e5871;")
              return line

          def manual_add_address(self):
              text = self.addr_input.text().strip()
              if not text: return
              try:
                  val = int(text)
                  self.ensure_user_exists(val)
                  # Simulate click to select logic
                  btn = self.user_data[val]['btn']
                  self.handle_address_click(btn, val)
                  self.addr_input.clear()
              except ValueError:
                  pass

          def ensure_user_exists(self, address_val):
              """Creates user context if it doesn't exist. Returns the user dict."""
              if address_val in self.user_data:
                  return self.user_data[address_val]

              self.added_addresses.add(address_val)

              # 1. Create Sidebar Button Widget
              btn_widget = QtWidgets.QWidget()
              btn_layout = QtWidgets.QHBoxLayout(btn_widget)
              btn_layout.setContentsMargins(0,0,0,0)
              
              # The actual clickable button
              btn = QtWidgets.QPushButton(f"Node {address_val}")
              btn.setCursor(QtCore.Qt.PointingHandCursor)
              btn.setStyleSheet(self.style_btn_normal)
              btn.setFixedHeight(50)
              
              # Unread Dot (Overlay logic via layout)
              # To make layout simple, we'll just put the dot inside the button text or next to it?
              # Let's use a layout approach:
              
              dot = QtWidgets.QLabel("●") 
              dot.setStyleSheet("color: #f1c40f; font-size: 16px; margin-right: 5px;") # Yellow dot
              dot.setVisible(False)

              # We need a custom widget click handling or just overlay the button
              # Simplification: Connect button click. The dot is separate but we track it.
              # Let's wrap btn and dot in a container? No, let's keep it simple.
              # We will add dot to the HBox inside the sidebar layout item?
              
              # Better approach: Subclass QPushButton or just add dot next to it
              container_widget = QtWidgets.QWidget()
              cw_layout = QtWidgets.QHBoxLayout(container_widget)
              cw_layout.setContentsMargins(0,0,0,0)
              cw_layout.setSpacing(0)
              
              # Helper logic to make the whole row clickable requires event filter, 
              # but let's just make the button fill the space and manage the dot internally?
              # Let's stick to the previous button style but change text color if unread?
              # Or just append a unicode dot to text?
              
              # Going with the clean layout approach:
              # [ Button (Stretches) ] [ Dot (Fixed) ]
              
              btn.clicked.connect(lambda checked, b=btn, a=address_val: self.handle_address_click(b, a))
              
              # Add to sidebar
              # We need to modify style to allow dot visibility. 
              # Actually, let's put the dot IN the button text for simplicity given the constraints
              # No, let's do it right.
              
              self.contact_layout.addWidget(btn)

              # 2. Create Chat Page
              new_chat_page = self._create_chat_page_widget()
              self.chat_stack.addWidget(new_chat_page)
              
              chat_layout = new_chat_page.widget().layout()
              
              # Store Data
              self.user_data[address_val] = {
                  "page": new_chat_page,
                  "layout": chat_layout,
                  "scroll_area": new_chat_page,
                  "btn": btn,
                  "has_unread": False
              }
              
              return self.user_data[address_val]

          def _create_chat_page_widget(self):
              scroll = WallpaperScrollArea(bg_image=self.bg_image_path)
              scroll.setStyleSheet("border: none; background-color: #e5ddd5;") 
              container = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(container)
              layout.setAlignment(QtCore.Qt.AlignTop)
              scroll.setWidget(container)
              container.setStyleSheet("background: transparent;")
              return scroll

          def handle_address_click(self, btn_obj, address_val):
              if self.is_waiting_for_ack:
                  return

              # Show input bar
              if self.input_box_wrapper.isHidden():
                  self.input_box_wrapper.show()

              # Update Button Styles
              if self.selected_btn and self.selected_btn != btn_obj:
                  self.selected_btn.setStyleSheet(self.style_btn_normal)
              
              btn_obj.setStyleSheet(self.style_btn_selected)
              self.selected_btn = btn_obj
              
              # Clear Unread
              if self.user_data[address_val]["has_unread"]:
                  self.user_data[address_val]["has_unread"] = False
                  btn_obj.setText(f"Node {address_val}") # Remove dot from text

              self.current_dest_address = address_val
              
              # Switch Stack
              target_page = self.user_data[address_val]["page"]
              self.chat_stack.setCurrentWidget(target_page)

              # Emit Address Change
              self.addr_selected_signal.emit(str(address_val))

          def on_send_click(self):
              if self.is_waiting_for_ack:
                  return

              text = self.msg_input.text().strip()
              if not text: return
              
              if self.current_dest_address is None:
                  return

              self._set_ui_busy_state(True)

              user_entry = self.user_data[self.current_dest_address]
              
              # Add SENT Bubble (Right side)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=True)
              
              self.send_to_gr_signal.emit(text)
              self.msg_input.clear()

          @QtCore.pyqtSlot(int, str)
          def handle_received_msg(self, src_addr, text):
              """Called when a PDU arrives from GNU Radio"""
              
              # 1. Ensure User Exists
              user_entry = self.ensure_user_exists(src_addr)
              
              # 2. Add RECEIVED Bubble (Left Side)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=False)
              
              # 3. Handle Unread Logic
              if self.current_dest_address != src_addr:
                  user_entry["has_unread"] = True
                  # Simple visual indicator: Append dot to button text
                  btn = user_entry["btn"]
                  if "●" not in btn.text():
                      btn.setText(f"Node {src_addr} ●")

          def _add_message_bubble(self, text, layout, scroll_area, is_sender):
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout(container)
              vbox.setContentsMargins(0,0,0,0)

              # Scroll for long text in bubble
              h_scroll = QtWidgets.QScrollArea()
              h_scroll.setWidgetResizable(True)
              h_scroll.setFixedHeight(60)
              h_scroll.setStyleSheet("background: transparent; border: none;")
              h_scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              h_scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)

              lbl = QtWidgets.QLabel(text)
              
              if is_sender:
                  # Green, Right Aligned
                  lbl.setStyleSheet("background-color: #dcf8c6; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignRight
              else:
                  # White, Left Aligned
                  lbl.setStyleSheet("background-color: #ffffff; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignLeft

              h_scroll.setWidget(lbl)
              h_scroll.setMinimumWidth(100)
              h_scroll.setMaximumWidth(450)
              lbl.adjustSize()
              h_scroll.setFixedHeight(lbl.height() + 25)

              # Timestamp
              ts_text = datetime.now().strftime("%H:%M")
              ts = QtWidgets.QLabel(ts_text)
              ts.setStyleSheet("color: grey; font-size: 10px;")
              ts.setAlignment(QtCore.Qt.AlignRight if is_sender else QtCore.Qt.AlignLeft)
              
              vbox.addWidget(h_scroll)
              vbox.addWidget(ts)

              # Horizontal Row Alignment
              row = QtWidgets.QHBoxLayout()
              if is_sender:
                  row.addStretch()
                  row.addWidget(container)
                  self._last_message_timestamp = ts # Track only my sent messages for ACK
              else:
                  row.addWidget(container)
                  row.addStretch()
              
              layout.addLayout(row)
              
              # Scroll to bottom
              QtCore.QTimer.singleShot(50, lambda: scroll_area.verticalScrollBar().setValue(scroll_area.verticalScrollBar().maximum()))

          def _set_ui_busy_state(self, is_busy):
              """Disables/Enables INPUT, SEND BTN, SIDEBAR, and ADD BTN"""
              self.is_waiting_for_ack = is_busy
              
              self.msg_input.setEnabled(not is_busy)
              self.send_btn.setEnabled(not is_busy)
              self.addr_input.setEnabled(not is_busy)
              self.add_btn.setEnabled(not is_busy)

              for addr, data in self.user_data.items():
                  data['btn'].setEnabled(not is_busy)
              
              if is_busy:
                  self.send_btn.setText("Wait...")
              else:
                  self.send_btn.setText("Send")
                  self.msg_input.setFocus()

          @QtCore.pyqtSlot(str)
          def handle_feedback(self, feedback):
              # ACK logic only applies to the last SENT message
              if hasattr(self, '_last_message_timestamp') and self._last_message_timestamp:
                  if feedback == "END_ACK_RECEIVED":
                      current_text = self._last_message_timestamp.text()
                      if "✓" not in current_text:
                          self._last_message_timestamp.setText(current_text + " ✓✓")
                          self._last_message_timestamp.setStyleSheet("color: #34B7F1; font-weight: bold; font-size: 10px;")
                  elif feedback == "RETRY_LIMIT_EXCEEDED":
                      self._last_message_timestamp.setText("Failed ❌")
                      self._last_message_timestamp.setStyleSheet("color: red; font-size: 10px;")
              
              self._set_ui_busy_state(False)

      # ==========================================
      # 3. GNU RADIO BLOCK
      # ==========================================
      class GuiSignaler(QtCore.QObject):
          feedback_signal = QtCore.pyqtSignal(str)
          receive_signal = QtCore.pyqtSignal(int, str) # addr, text

      class messenger_gui(gr.basic_block):
          """
          Inputs: 
             'in' (PDUs from receiver)
             'feedback' (ACK/NACK)
          Outputs: 
             'out' (payload), 
             'dest_addr' (selected address)
          """
          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              # Registers
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("dest_addr"))
              
              self.message_port_register_in(pmt.intern("in"))      # Incoming PDU
              self.message_port_register_in(pmt.intern("feedback")) # ACKs

              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback_msg)
              self.set_msg_handler(pmt.intern("in"), self._process_incoming_pdu)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.signaler = GuiSignaler()
              self.gui_window = MessengerWindow(bg_image=bg_image)
              
              # Connections
              self.signaler.feedback_signal.connect(self.gui_window.handle_feedback)
              self.signaler.receive_signal.connect(self.gui_window.handle_received_msg)
              
              self.gui_window.send_to_gr_signal.connect(self._send_payload)
              self.gui_window.addr_selected_signal.connect(self._send_dest_addr)

              self.gui_window.show()

          def _process_feedback_msg(self, msg):
              try:
                  if pmt.is_symbol(msg):
                      s = pmt.symbol_to_string(msg)
                      self.signaler.feedback_signal.emit(s)
              except Exception:
                  pass

          def _process_incoming_pdu(self, msg):
              """
              Expects PDU: Pair(Meta, u8vector).
              Byte 0 = Sender Address.
              Bytes 1+ = Text.
              """
              try:
                  if not pmt.is_pair(msg): return
                  vec = pmt.cdr(msg)
                  if not pmt.is_u8vector(vec): return
                  
                  data = bytearray(pmt.u8vector_elements(vec))
                  if len(data) < 1: return
                  
                  sender_addr = data[0] # Byte 0
                  payload = data[1:]    # Remaining bytes
                  
                  text = payload.decode("utf-8", errors="ignore")
                  
                  # Emit to GUI
                  self.signaler.receive_signal.emit(sender_addr, text)
                  
              except Exception as e:
                  print(f"Error processing input PDU: {e}")

          def _send_payload(self, text_msg):
              self.message_port_pub(pmt.intern("out"), pmt.string_to_symbol(text_msg))

          def _send_dest_addr(self, addr_str):
              self.message_port_pub(pmt.intern("dest_addr"), pmt.string_to_symbol(addr_str))
    bg_image: '''Networks_Telecommunications1.jpg'''
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    BitLimiter (fixed byte count):\n    - Wait for tag with name tag_key\n    - When seen, forward exactly packet_bytes bytes\n    \"\"\"\n\n    def __init__(self, tag_key=\"packet_start\", packet_bytes=32):\n        gr.sync_block.__init__(\n            self,\n            name=\"BitLimiterBytes\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8]\n        )\n\n        self.tag_key = pmt.intern(tag_key)\n        self.packet_bytes = int(packet_bytes)\n\n        # State\n        self.active = False\n        self.bytes_remaining = 0\n\n    def work(self, input_items, output_items):\n\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_in = len(inp)\n        out_index = 0\n\n        # ---- Detect tag ----\n        tags = self.get_tags_in_window(0, 0, n_in)\n\n        for t in tags:\n            if t.key == self.tag_key:\n                # Start forwarding packet_bytes bytes\n                self.bytes_remaining = self.packet_bytes\n                self.active = True\n\n        # ---- Forward data ----\n        for i in range(n_in):\n\n            if self.active and self.bytes_remaining > 0:\n                out[out_index] = inp[i]\n                out_index += 1\n                self.bytes_remaining -= 1\n\n                if self.bytes_remaining == 0:\n                    self.active = False\n\n        return out_index\n\n"
    packet_bytes: '8'
    tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):

          def __init__(self, num_bytes=4):
              gr.basic_block.__init__(
                  self,
                  name="PDU Prepend Random Bytes",
                  in_sig=None,
                  out_sig=None
              )

              self.num_bytes = int(num_bytes)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_msg)


          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = pmt.cdr(msg)

              payload = bytes(pmt.u8vector_elements(vec))

              # random bytes
              prepend = np.random.randint(0, 256, self.num_bytes, dtype=np.uint8).tolist()

              # convert payload to list of ints
              payload_list = list(payload)

              # final output list
              out_list = prepend + payload_list

              # convert back to PDU
              out_vec = pmt.init_u8vector(len(out_list), out_list)

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(meta, out_vec)
              )
    num_bytes: '10000'
  states: {state: disabled}
- name: epy_block_11
  id: epy_block
  parameters:
    _source_code: "import pmt\nimport os\nimport threading\nimport time\nfrom gnuradio import gr\n\nclass TextToPDU_ARQ(gr.basic_block):\n    def __init__(self, max_packet_size=32, src_address=1, dest_address=2):\n        gr.basic_block.__init__(\n            self,\n            name=\"Text to PDU (ARQ Logic + 10000 Bytes Prepend)\",\n            in_sig=[],\n            out_sig=[]\n        )\n        \n        # --- CONFIGURATION ---\n        self.interval = 0.1\n        self.max_packet_size = int(max_packet_size)\n        self.src_address = int(src_address) & 0xFF\n        self.dest_address = int(dest_address) & 0xFF\n        self._sync_bits = 10000\n        # -------------------\n\n        # Hardcoded 10000 bytes (example: repeating pattern 0x12..0xF0)\n        base = [0x12, 0x34, 0x56, 0x78, 0x9A, 0xBC, 0xDE, 0xF0]\n        self.prepend_bytes = (base * 10000)[:10000]\n        print(\"prepend ready\")\n\n        # Message ports\n        self.message_port_register_out(pmt.intern(\"pdus\"))\n        self.message_port_register_in(pmt.intern(\"ack_bits\"))\n        self.set_msg_handler(pmt.intern(\"ack_bits\"), self.handle_ack_bits)\n\n        self.message_port_register_in(pmt.intern(\"msg_in\"))\n        self.set_msg_handler(pmt.intern(\"msg_in\"), self.handle_msg_input)\n        self.message_port_register_out(pmt.intern(\"status_out\"))\n\n        # Threading / state\n        self._stop_event = threading.Event()\n        self._ack_event = threading.Event()\n        self._ack_lock = threading.Lock()\n        self._expected_ack = None\n        self._tx_lock = threading.Lock()\n\n    def stop(self):\n        self._stop_event.set()\n        self._ack_event.set()\n        return super().stop()\n\n    def handle_msg_input(self, msg):\n        text_data = pmt.symbol_to_string(msg)\n        if self._tx_lock.locked():\n            return\n        t = threading.Thread(target=self._process_transmission, args=(text_data,))\n        t.daemon = True\n        t.start()\n    \n        # -------------------------------------------------\n    # Sync Burst Sender (PURE RANDOM BYTES)\n    # -------------------------------------------------\n    def _send_sync_burst(self):\n        if self._sync_bits <= 0:\n            return\n\n        # Pure random bytes, no header\n        sync_data = os.urandom(self._sync_bits)\n\n        vec = pmt.init_u8vector(len(sync_data), list(sync_data))\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        print(f\"[pdu_text_gui] SYNC BURST sent ({len(sync_data)} bytes)\")\n        self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n    def _process_transmission(self, text_data):\n        with self._tx_lock:\n            self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"pending\"))\n            \n            data = text_data.encode('utf-8')\n            chunk_size = self.max_packet_size - 3\n            chunks = [data[i:i + chunk_size] for i in range(0, len(data), chunk_size)]\n\n            packet_number = 1\n            success = True\n\n            # --- SEND NORMAL PACKETS ---\n            for chunk in chunks:\n                if self._stop_event.is_set():\n                    success = False\n                    break\n\n                # prepend 10000 bytes\n                full_packet = bytes([self.src_address, self.dest_address, packet_number]) + chunk\n                payload = pmt.init_u8vector(len(full_packet), list(full_packet))\n                #pdu = pmt.cons(pmt.make_dict(), payload)\n                \n                self._send_sync_burst()\n                pdu = pmt.cons(pmt.PMT_NIL, payload)\n\n                with self._ack_lock:\n                    self._expected_ack = packet_number\n                    self._ack_event.clear()\n\n                retry_count = 0\n                max_retries = 200\n                chunk_sent_successfully = False\n\n                while not self._stop_event.is_set() and retry_count < max_retries:\n                    self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n                    ack_received = self._ack_event.wait(timeout=self.interval)\n                    if ack_received:\n                        chunk_sent_successfully = True\n                        break\n                    else:\n                        retry_count += 1\n\n                if not chunk_sent_successfully:\n                    print(f\"[ARQ] Failed to send packet #{packet_number:02X}\")\n                    success = False\n                    break\n\n                packet_number = (packet_number + 1) & 0xFF\n                if packet_number == 0x00:\n                    packet_number = 0x01\n\n            # --- SEND TERMINATION PACKET ---\n            if success and not self._stop_event.is_set():\n                term_packet_number = packet_number\n                term_payload_len = (self.max_packet_size + 1) - 3\n                term_payload = bytes([0xFF] * term_payload_len)\n\n                full_packet = bytes([self.src_address, self.dest_address, term_packet_number]) + term_payload\n                payload = pmt.init_u8vector(len(full_packet), list(full_packet))\n                #pdu = pmt.cons(pmt.make_dict(), payload)\n                \n                self._send_sync_burst()\n                pdu = pmt.cons(pmt.PMT_NIL, payload)\n\n                with self._ack_lock:\n                    self._expected_ack = term_packet_number\n                    self._ack_event.clear()\n\n\n                retry_count = 0\n                max_retries = 200\n                term_success = False\n\n                while not self._stop_event.is_set() and retry_count < max_retries:\n                    self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n                    ack_received = self._ack_event.wait(timeout=self.interval)\n                    if ack_received:\n                        term_success = True\n                        break\n                    else:\n                        print(f\"[ARQ] Timeout waiting for TERMINATION ACK #{term_packet_number:02X}\")\n                        retry_count += 1\n\n                if not term_success:\n                    print(f\"[ARQ] Failed to send TERMINATION packet #{term_packet_number:02X}\")\n                    success = False\n\n            # Update GUI\n            if success:\n                self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"success\"))\n            else:\n                self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"fail\"))\n\n    def handle_ack_bits(self, msg):\n        try:\n            data = pmt.cdr(msg)\n            if not pmt.is_u8vector(data):\n                return\n\n            byte_data = bytearray(pmt.u8vector_elements(data))\n            if len(byte_data) < 4:\n                return\n            \n            if byte_data[0] != 0xAA:\n                return\n\n            ack_src_addr = byte_data[1]\n            ack_dest_addr = byte_data[2]\n            ack_packet_num = byte_data[3]\n\n            if ack_dest_addr != self.src_address:\n                return\n            if ack_src_addr != self.dest_address:\n                return\n\n            with self._ack_lock:\n                if ack_packet_num == self._expected_ack:\n                    self._ack_event.set()\n                    \n        except Exception as e:\n            print(f\"[ARQ] Error handling ACK: {str(e)}\")\n\n"
    dest_address: '2'
    max_packet_size: '32'
    src_address: '1'
  states: {state: disabled}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import threading
      import pmt
      import time
      import os
      from gnuradio import gr

      class TextToPDU_ARQ(gr.basic_block):
          def __init__(self, pkt_size=32, src_addr=1, dst_addr=2,
                       sync_burst_bytes=10000, timeout=0.1, retry_limit=200):

              gr.basic_block.__init__(
                  self,
                  name="Text to PDU ARQ (Variable Burst)",
                  in_sig=[],
                  out_sig=[]
              )

              # ---------------- PARAMETERS ----------------
              self._pkt_size = int(pkt_size)
              self._src = int(src_addr) & 0xFF
              self._dst = int(dst_addr) & 0xFF
              
              # --- BURST SIZES SETUP ---
              self._sync_len_first = int(sync_burst_bytes) # Default: 10000
              self._sync_len_next = 5000                   # Fixed: 160
              
              self._timeouttotal = 0.5
              
              self._timeout = float(timeout)
              self._retry_limit = int(retry_limit)
              # --------------------------------------------

              # Ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_in(pmt.intern("ack_in"))
              
              # --- NEW PORT FOR GUI ADDRESS UPDATES ---
              self.message_port_register_in(pmt.intern("dest_addr_in"))
              self.set_msg_handler(pmt.intern("dest_addr_in"), self._update_dest_addr)
              
              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("status_out"))

              self.set_msg_handler(pmt.intern("msg_in"), self._process_text)
              self.set_msg_handler(pmt.intern("ack_in"), self._process_ack)

              # State
              self._tx_thread = None
              self._stop = threading.Event()
              self._ack_event = threading.Event()
              self._ack_lock = threading.Lock()
              self._expected_ack = None

          def _update_dest_addr(self, msg):
              """Updates the destination address from the GUI signal."""
              try:
                  # GUI sends address as a string symbol (e.g. "2")
                  if pmt.is_symbol(msg):
                      val_str = pmt.symbol_to_string(msg)
                      new_addr = int(val_str)
                      self._dst = new_addr & 0xFF
                      print(f"[ARQ] Destination set to: {self._dst}")
                  elif pmt.is_integer(msg):
                      self._dst = pmt.to_long(msg) & 0xFF
              except Exception as e:
                  print(f"[ARQ] Error updating address: {e}")

          def _send_prepend_burst(self, length):
              if length <= 0: return
              raw = os.urandom(length)
              vec = pmt.init_u8vector(len(raw), list(raw))
              pdu = pmt.cons(pmt.PMT_NIL, vec)
              self.message_port_pub(pmt.intern("pdus"), pdu)

          def _process_text(self, msg):
              try:
                  text = pmt.symbol_to_string(msg)
              except:
                  return

              if self._tx_thread is None or not self._tx_thread.is_alive():
                  self._stop.clear()
                  self._tx_thread = threading.Thread(target=self._run, args=(text,))
                  self._tx_thread.daemon = True
                  self._tx_thread.start()

          def _run(self, text):
              data = text.encode("utf-8")
              chunk_size = self._pkt_size - 3
              chunks = [data[i:i+chunk_size] for i in range(0, len(data), chunk_size)]

              pkt_num = 1
              success = True

              # ---------------- NORMAL PACKETS ----------------
              if pkt_num == 0:
                  current_burst_len = self._sync_len_first
              else:
                  current_burst_len = self._sync_len_next
                  
              for chunk in chunks:
                  if not self._send_single_packet(chunk, pkt_num, current_burst_len):
                      success = False
                      break

                  pkt_num = (pkt_num + 1) & 0xFF
                  if pkt_num == 0:
                      pkt_num = 1

              # ---------------- TERMINATION PACKET ----------------
              if success and not self._stop.is_set():
                  term_size = (self._pkt_size + 1) - 3
                  term_payload = bytes([0xFF] * term_size)
                  
                  if not self._send_single_packet(term_payload, pkt_num, self._sync_len_next, termination=True):
                      success = False

              # ---------------- UPDATE GUI ----------------
              if success:
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("success"))
              else:
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("fail"))

          def _send_single_packet(self, chunk, pkt_num, burst_len, termination=False):
              header = bytes([self._src, self._dst, pkt_num])
              full_packet = header + chunk

              vec = pmt.init_u8vector(len(full_packet), list(full_packet))
              pdu = pmt.cons(pmt.PMT_NIL, vec)

              with self._ack_lock:
                  self._expected_ack = pkt_num
                  self._ack_event.clear()

              retries = 0

              while retries < self._retry_limit and not self._stop.is_set():
                  if self._retry_limit % 10 == 0:
                      self._send_prepend_burst(burst_len)

                  # SEND PACKET
                  self.message_port_pub(pmt.intern("pdus"), pdu)
                  print(f"[ARQ] Sent packet #{pkt_num:02X} (Burst: {burst_len})")

                  # WAIT FOR ACK
                  print(f"waiting for chunk ack")
                  if self._ack_event.wait(timeout=self._timeouttotal):
                      print(f"[ARQ] ACK for #{pkt_num:02X}")
                      return True

                  retries += 1
                  print(f"[ARQ] Timeout -> retry {retries}")
              
              print(f"[ARQ] FAILED packet #{pkt_num:02X}")
              return False

          def _process_ack(self, msg):
              try:
                  data = pmt.cdr(msg)
                  if not pmt.is_u8vector(data): return

                  arr = bytearray(pmt.u8vector_elements(data))
                  if len(arr) < 4: return
                  if arr[0] != 0xAA: return

                  src = arr[1]
                  dst = arr[2]
                  ack_id = arr[3]

                  if src != self._dst or dst != self._src:
                      return

                  with self._ack_lock:
                      if ack_id == self._expected_ack:
                          self._ack_event.set()
                          
              except Exception as e:
                  print(f"[ARQ] ACK error: {e}")
    dst_addr: '2'
    pkt_size: '32'
    retry_limit: '60'
    src_addr: '1'
    sync_burst_bytes: '10000'
    timeout: '0.01'
  states: {}
- name: epy_block_13
  id: epy_block
  parameters:
    _source_code: "import os\nimport pmt\nfrom gnuradio import gr\n\nclass ack_sync_prepender(gr.basic_block):\n    \"\"\"\n    Inserts a sync burst BEFORE every ACK PDU.\n    1st ACK: 10,000 bytes burst\n    Subsequent ACKs: 1,000 bytes burst\n    \"\"\"\n\n    def __init__(self, sync_len_first=10000):\n        gr.basic_block.__init__(\n            self,\n            name=\"ack_sync_prepender\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # --- BURST SIZE CONFIGURATION ---\n        self.sync_len_first = int(sync_len_first)  # Default: 10000\n        self.sync_len_next = 2000                  # Fixed: 1000\n        \n        # --- STATE ---\n        # Keeps track if we have sent the first ACK yet\n        self._is_first_ack = True\n\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n        self.message_port_register_out(pmt.intern(\"ack_out\"))\n\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self.handle_ack)\n\n\n    # --------------------------------------------------------\n    # This function CREATES + PUBLISHES the sync burst\n    # --------------------------------------------------------\n    def send_sync_burst(self, length):\n        \n        # Create random bytes of exactly 'length' size\n        sync_data = os.urandom(length)\n\n        vec = pmt.init_u8vector(length, list(sync_data))\n        burst_pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        # <---- the burst is SENT here ---->\n        self.message_port_pub(pmt.intern(\"ack_out\"), burst_pdu)\n\n        # Debug print (Optional)\n        # if length > 2000:\n        #     print(f\"[ACK SYNC] Sent FIRST burst ({length} bytes)\")\n        # else:\n        #     print(f\"[ACK SYNC] Sent burst ({length} bytes)\")\n\n\n    # --------------------------------------------------------\n    # ACK handler\n    # --------------------------------------------------------\n    def handle_ack(self, msg):\n        \"\"\"\n        msg is the original ACK PDU.\n\n        This block outputs:\n            [SYNC BURST (Variable Size)]\n            [ACK PDU]\n        \"\"\"\n        \n        # --- DECIDE BURST SIZE ---\n        if self._is_first_ack:\n            current_len = self.sync_len_first\n            self._is_first_ack = False # Mark that we have handled the first one\n        else:\n            current_len = self.sync_len_next\n\n        # 1) send the sync burst with the calculated length\n        self.send_sync_burst(current_len)\n\n        # 2) forward ACK\n        for _ in range(10):\n            self.message_port_pub(pmt.intern(\"ack_out\"), msg)\n\n"
    sync_len_first: '10000'
  states: {}
- name: epy_block_14
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import datetime

      # ==========================================
      # 1. CUSTOM UI COMPONENTS
      # ==========================================

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap and not self.bg_pixmap.isNull():
                  painter = QtGui.QPainter(self.viewport())
                  scaled_pixmap = self.bg_pixmap.scaled(
                      self.viewport().size(),
                      QtCore.Qt.KeepAspectRatioByExpanding,
                      QtCore.Qt.SmoothTransformation
                  )
                  x = (self.viewport().width() - scaled_pixmap.width()) // 2
                  y = (self.viewport().height() - scaled_pixmap.height()) // 2
                  painter.drawPixmap(x, y, scaled_pixmap)
              super().paintEvent(event)

      # ==========================================
      # 2. THE MAIN WINDOW (GUI LOGIC)
      # ==========================================
      class MessengerWindow(QtWidgets.QWidget):
          # Signals to GR
          send_to_gr_signal = QtCore.pyqtSignal(str)
          addr_selected_signal = QtCore.pyqtSignal(str)

          def __init__(self, bg_image=""):
              super().__init__()
              self.setWindowTitle("BellLabz - Control Center")
              self.resize(950, 700)
              self.bg_image_path = bg_image
              
              # --- STATE FLAGS ---
              self.is_waiting_for_ack = False 
              
              # --- DATA STRUCTURES ---
              self.added_addresses = set()
              self.selected_btn = None 
              self.current_dest_address = None
              
              # Structure: { addr_int: {'page': widget, 'layout': box, 'scroll': area, 'btn': btn_obj, 'dot': dot_label} }
              self.user_data = {} 

              # --- STYLES ---
              self.style_btn_normal = """
                  QPushButton {
                      background-color: #34495e; color: #ecf0f1; border: 1px solid #2c3e50;
                      padding: 12px; border-radius: 6px; text-align: left;
                  }
                  QPushButton:hover { background-color: #4b6584; }
                  QPushButton:disabled { background-color: #2c3e50; color: #7f8c8d; border: 1px solid #2c3e50; }
              """
              self.style_btn_selected = """
                  QPushButton {
                      background-color: #27ae60; color: white; border: 2px solid white;
                      padding: 12px; border-radius: 6px; text-align: left; font-weight: bold;
                  }
                  QPushButton:disabled { background-color: #2ecc71; opacity: 0.7; }
              """

              # --- MAIN LAYOUT ---
              self.main_layout = QtWidgets.QHBoxLayout()
              self.main_layout.setContentsMargins(0, 0, 0, 0)
              self.main_layout.setSpacing(0)
              self.setLayout(self.main_layout)

              self._init_sidebar()
              self._init_right_panel()

          def _init_sidebar(self):
              self.sidebar = QtWidgets.QWidget()
              self.sidebar.setFixedWidth(250)
              self.sidebar.setStyleSheet("background-color: #2c3e50; border-right: 1px solid #1a252f;")
              layout = QtWidgets.QVBoxLayout(self.sidebar)
              layout.setSpacing(10)

              header = QtWidgets.QLabel("CHATS")
              header.setStyleSheet("color: #95a5a6; font-weight: bold; margin-top: 10px; font-size: 14px;")
              layout.addWidget(header)

              # Input
              input_con = QtWidgets.QHBoxLayout()
              self.addr_input = QtWidgets.QLineEdit()
              self.addr_input.setPlaceholderText("ID (0-255)")
              self.addr_input.setStyleSheet("""
                  QLineEdit { background: #ecf0f1; border: none; border-radius: 4px; padding: 8px; color: black; }
                  QLineEdit:disabled { background: #95a5a6; color: #555; }
              """)
              self.addr_input.setValidator(QtGui.QIntValidator(0, 255))
              self.addr_input.returnPressed.connect(self.manual_add_address)

              self.add_btn = QtWidgets.QPushButton("+")
              self.add_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.add_btn.setFixedWidth(40)
              self.add_btn.clicked.connect(self.manual_add_address)
              self.add_btn.setStyleSheet("""
                  QPushButton { background: #3498db; color: white; border: none; border-radius: 4px; font-weight: bold; }
                  QPushButton:disabled { background: #7f8c8d; }
              """)
              
              input_con.addWidget(self.addr_input)
              input_con.addWidget(self.add_btn)
              layout.addLayout(input_con)

              layout.addWidget(self._create_separator())

              # Contact List Scroll
              self.contact_scroll = QtWidgets.QScrollArea()
              self.contact_scroll.setWidgetResizable(True)
              self.contact_scroll.setStyleSheet("border: none; background: transparent;")
              
              self.contact_container = QtWidgets.QWidget()
              self.contact_layout = QtWidgets.QVBoxLayout(self.contact_container)
              self.contact_layout.setAlignment(QtCore.Qt.AlignTop)
              self.contact_layout.setSpacing(5)
              self.contact_scroll.setWidget(self.contact_container)

              layout.addWidget(self.contact_scroll)
              self.main_layout.addWidget(self.sidebar)

          def _init_right_panel(self):
              right_panel = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(right_panel)
              layout.setContentsMargins(0, 0, 0, 0)
              layout.setSpacing(0)

              # Stack for Chat Pages
              self.chat_stack = QtWidgets.QStackedWidget()
              welcome_page = QtWidgets.QLabel("Select a contact to start messaging")
              welcome_page.setAlignment(QtCore.Qt.AlignCenter)
              welcome_page.setStyleSheet("background-color: #e5ddd5; color: #888; font-size: 18px;")
              self.chat_stack.addWidget(welcome_page)
              layout.addWidget(self.chat_stack, stretch=1)

              # Input Area
              self.input_box_wrapper = QtWidgets.QWidget()
              self.input_box_wrapper.setStyleSheet("background-color: #f0f0f0; border-top: 1px solid #dcdcdc;")
              input_box_layout = QtWidgets.QHBoxLayout(self.input_box_wrapper)
              input_box_layout.setContentsMargins(10, 10, 10, 10)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message...")
              self.msg_input.setStyleSheet("""
                  QLineEdit { border-radius: 20px; padding: 10px 15px; background: white; border: 1px solid #ccc; font-size: 14px; }
                  QLineEdit:disabled { background-color: #e0e0e0; color: #888; }
              """)
              
              self.send_btn = QtWidgets.QPushButton("Send")
              self.send_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.send_btn.setStyleSheet("""
                  QPushButton { background-color: #008069; color: white; border-radius: 20px; padding: 10px 20px; font-weight: bold; }
                  QPushButton:disabled { background-color: #95a5a6; }
              """)
              
              self.msg_input.returnPressed.connect(self.on_send_click)
              self.send_btn.clicked.connect(self.on_send_click)

              input_box_layout.addWidget(self.msg_input)
              input_box_layout.addWidget(self.send_btn)

              layout.addWidget(self.input_box_wrapper)
              self.main_layout.addWidget(right_panel)
              
              self.input_box_wrapper.hide()

          def _create_separator(self):
              line = QtWidgets.QFrame()
              line.setFrameShape(QtWidgets.QFrame.HLine)
              line.setStyleSheet("color: #3e5871;")
              return line

          def manual_add_address(self):
              text = self.addr_input.text().strip()
              if not text: return
              try:
                  val = int(text)
                  self.ensure_user_exists(val)
                  # Simulate click to select logic
                  btn = self.user_data[val]['btn']
                  self.handle_address_click(btn, val)
                  self.addr_input.clear()
              except ValueError:
                  pass

          def ensure_user_exists(self, address_val):
              """Creates user context if it doesn't exist."""
              if address_val in self.user_data:
                  return self.user_data[address_val]

              self.added_addresses.add(address_val)

              # 1. Create Sidebar Button Widget
              btn = QtWidgets.QPushButton(f"Node {address_val}")
              btn.setCursor(QtCore.Qt.PointingHandCursor)
              btn.setStyleSheet(self.style_btn_normal)
              btn.setFixedHeight(50)
              
              btn.clicked.connect(lambda checked, b=btn, a=address_val: self.handle_address_click(b, a))
              self.contact_layout.addWidget(btn)

              # 2. Create Chat Page
              new_chat_page = self._create_chat_page_widget()
              self.chat_stack.addWidget(new_chat_page)
              
              chat_layout = new_chat_page.widget().layout()
              
              # Store Data
              self.user_data[address_val] = {
                  "page": new_chat_page,
                  "layout": chat_layout,
                  "scroll_area": new_chat_page,
                  "btn": btn,
                  "has_unread": False
              }
              
              return self.user_data[address_val]

          def _create_chat_page_widget(self):
              scroll = WallpaperScrollArea(bg_image=self.bg_image_path)
              scroll.setStyleSheet("border: none; background-color: #e5ddd5;") 
              container = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(container)
              layout.setAlignment(QtCore.Qt.AlignTop)
              scroll.setWidget(container)
              container.setStyleSheet("background: transparent;")
              return scroll

          def handle_address_click(self, btn_obj, address_val):
              if self.is_waiting_for_ack:
                  return

              if self.input_box_wrapper.isHidden():
                  self.input_box_wrapper.show()

              if self.selected_btn and self.selected_btn != btn_obj:
                  self.selected_btn.setStyleSheet(self.style_btn_normal)
              
              btn_obj.setStyleSheet(self.style_btn_selected)
              self.selected_btn = btn_obj
              
              if self.user_data[address_val]["has_unread"]:
                  self.user_data[address_val]["has_unread"] = False
                  btn_obj.setText(f"Node {address_val}") # Remove dot

              self.current_dest_address = address_val
              
              target_page = self.user_data[address_val]["page"]
              self.chat_stack.setCurrentWidget(target_page)

              # Emit Address Change to GR Block
              self.addr_selected_signal.emit(str(address_val))

          def on_send_click(self):
              if self.is_waiting_for_ack:
                  return

              text = self.msg_input.text().strip()
              if not text: return
              
              if self.current_dest_address is None:
                  return

              self._set_ui_busy_state(True)

              user_entry = self.user_data[self.current_dest_address]
              
              # Add SENT Bubble
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=True)
              
              self.send_to_gr_signal.emit(text)
              self.msg_input.clear()

          @QtCore.pyqtSlot(int, str)
          def handle_received_msg(self, src_addr, text):
              """Called when a PDU arrives from GNU Radio"""
              user_entry = self.ensure_user_exists(src_addr)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=False)
              
              if self.current_dest_address != src_addr:
                  user_entry["has_unread"] = True
                  btn = user_entry["btn"]
                  if "●" not in btn.text():
                      btn.setText(f"Node {src_addr} ●")

          def _add_message_bubble(self, text, layout, scroll_area, is_sender):
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout(container)
              vbox.setContentsMargins(0,0,0,0)

              h_scroll = QtWidgets.QScrollArea()
              h_scroll.setWidgetResizable(True)
              h_scroll.setFixedHeight(60)
              h_scroll.setStyleSheet("background: transparent; border: none;")
              h_scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              h_scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)

              lbl = QtWidgets.QLabel(text)
              
              if is_sender:
                  lbl.setStyleSheet("background-color: #dcf8c6; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignRight
              else:
                  lbl.setStyleSheet("background-color: #ffffff; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignLeft

              h_scroll.setWidget(lbl)
              h_scroll.setMinimumWidth(100)
              h_scroll.setMaximumWidth(450)
              lbl.adjustSize()
              h_scroll.setFixedHeight(lbl.height() + 25)

              ts_text = datetime.now().strftime("%H:%M")
              ts = QtWidgets.QLabel(ts_text)
              ts.setStyleSheet("color: grey; font-size: 10px;")
              ts.setAlignment(QtCore.Qt.AlignRight if is_sender else QtCore.Qt.AlignLeft)
              
              vbox.addWidget(h_scroll)
              vbox.addWidget(ts)

              row = QtWidgets.QHBoxLayout()
              if is_sender:
                  row.addStretch()
                  row.addWidget(container)
                  self._last_message_timestamp = ts 
              else:
                  row.addWidget(container)
                  row.addStretch()
              
              layout.addLayout(row)
              QtCore.QTimer.singleShot(50, lambda: scroll_area.verticalScrollBar().setValue(scroll_area.verticalScrollBar().maximum()))

          def _set_ui_busy_state(self, is_busy):
              self.is_waiting_for_ack = is_busy
              self.msg_input.setEnabled(not is_busy)
              self.send_btn.setEnabled(not is_busy)
              self.addr_input.setEnabled(not is_busy)
              self.add_btn.setEnabled(not is_busy)

              for addr, data in self.user_data.items():
                  data['btn'].setEnabled(not is_busy)
              
              if is_busy:
                  self.send_btn.setText("Wait...")
              else:
                  self.send_btn.setText("Send")
                  self.msg_input.setFocus()

          @QtCore.pyqtSlot(str)
          def handle_feedback(self, feedback):
              if hasattr(self, '_last_message_timestamp') and self._last_message_timestamp:
                  if feedback == "END_ACK_RECEIVED":
                      current_text = self._last_message_timestamp.text()
                      if "✓" not in current_text:
                          self._last_message_timestamp.setText(current_text + " ✓✓")
                          self._last_message_timestamp.setStyleSheet("color: #34B7F1; font-weight: bold; font-size: 10px;")
                  elif feedback == "RETRY_LIMIT_EXCEEDED":
                      self._last_message_timestamp.setText("Failed ❌")
                      self._last_message_timestamp.setStyleSheet("color: red; font-size: 10px;")
              
              self._set_ui_busy_state(False)

      # ==========================================
      # 3. GNU RADIO BLOCK
      # ==========================================
      class GuiSignaler(QtCore.QObject):
          feedback_signal = QtCore.pyqtSignal(str)
          receive_signal = QtCore.pyqtSignal(int, str) # addr, text

      class messenger_gui(gr.basic_block):
          """
          Inputs: 
             'in' (PDUs from receiver)
             'feedback' (ACK/NACK)
          Outputs: 
             'out' (payload), 
             'dest_addr' (selected address)
          """
          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("dest_addr"))
              
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_in(pmt.intern("feedback"))

              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback_msg)
              self.set_msg_handler(pmt.intern("in"), self._process_incoming_pdu)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.signaler = GuiSignaler()
              self.gui_window = MessengerWindow(bg_image=bg_image)
              
              self.signaler.feedback_signal.connect(self.gui_window.handle_feedback)
              self.signaler.receive_signal.connect(self.gui_window.handle_received_msg)
              
              self.gui_window.send_to_gr_signal.connect(self._send_payload)
              self.gui_window.addr_selected_signal.connect(self._send_dest_addr)

              self.gui_window.show()

          def _process_feedback_msg(self, msg):
              try:
                  if pmt.is_symbol(msg):
                      s = pmt.symbol_to_string(msg)
                      self.signaler.feedback_signal.emit(s)
              except Exception:
                  pass

          def _process_incoming_pdu(self, msg):
              """
              Expects PDU: Pair(Meta, u8vector).
              Byte 0 = Sender Address.
              Bytes 1+ = Text.
              """
              try:
                  if not pmt.is_pair(msg): return
                  vec = pmt.cdr(msg)
                  if not pmt.is_u8vector(vec): return
                  
                  data = bytearray(pmt.u8vector_elements(vec))
                  if len(data) < 1: return
                  
                  sender_addr = data[0] # Byte 0
                  payload = data[1:]    # Remaining bytes
                  
                  text = payload.decode("utf-8", errors="ignore")
                  
                  self.signaler.receive_signal.emit(sender_addr, text)
                  
              except Exception as e:
                  print(f"Error processing input PDU: {e}")

          def _send_payload(self, text_msg):
              self.message_port_pub(pmt.intern("out"), pmt.string_to_symbol(text_msg))

          def _send_dest_addr(self, addr_str):
              self.message_port_pub(pmt.intern("dest_addr"), pmt.string_to_symbol(addr_str))
    bg_image: '""'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      try:
          from Crypto.Cipher import AES
      except ImportError:
          AES = None

      class aes_gcm_decrypt_pdu(gr.basic_block):
          def __init__(self, key_hex="00112233445566778899aabbccddeeff"):
              gr.basic_block.__init__(self,
                  name="AES-GCM Decrypt (PDU)",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.set_msg_handler(pmt.intern("pdus_in"), self._handle)
              self.message_port_register_out(pmt.intern("pdus_out"))

              self.key = bytes.fromhex(key_hex)
              if AES is None:
                  print("[AES-GCM Decrypt] ERROR: PyCryptodome not found. Install with: pip install pycryptodome")

          def _handle(self, msg):
              if AES is None:
                  return
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  print("[AES-GCM Decrypt] Non-u8vector payload")
                  return
              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) < 1 + 12 + 16:
                  print("[AES-GCM Decrypt] Frame too short")
                  return

              seq = bytes([data[0]])
              iv  = bytes(data[1:1+12])
              tag = bytes(data[-16:])
              ciphertext = bytes(data[1+12:-16])

              try:
                  cipher = AES.new(self.key, AES.MODE_GCM, nonce=iv)
                  cipher.update(seq)  # must match encrypt side
                  plain = cipher.decrypt_and_verify(ciphertext, tag)
              except Exception as e:
                  print(f"[AES-GCM Decrypt] Auth failed: {e}")
                  return  # drop corrupted/forged frame

              # Rebuild original PDU payload: [seq][plaintext]
              out = seq + plain
              out_u8 = pmt.init_u8vector(len(out), list(out))
              out_pdu = pmt.cons(meta, out_u8)
              self.message_port_pub(pmt.intern("pdus_out"), out_pdu)
    key_hex: '''00112233445566778899aabbccddeeff'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          BitLimiter (fixed byte count):
          - Wait for tag with name tag_key
          - When seen, forward exactly packet_bytes bytes
          """

          def __init__(self, tag_key="packet_start", packet_bytes=32):
              gr.sync_block.__init__(
                  self,
                  name="BitLimiterBytes",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_key)
              self.packet_bytes = int(packet_bytes)

              # State
              self.active = False
              self.bytes_remaining = 0

          def work(self, input_items, output_items):

              inp = input_items[0]
              out = output_items[0]

              n_in = len(inp)
              out_index = 0

              # ---- Detect tag ----
              tags = self.get_tags_in_window(0, 0, n_in)

              for t in tags:
                  if t.key == self.tag_key:
                      # Start forwarding packet_bytes bytes
                      self.bytes_remaining = self.packet_bytes
                      self.active = True

              # ---- Forward data ----
              for i in range(n_in):

                  if self.active and self.bytes_remaining > 0:
                      out[out_index] = inp[i]
                      out_index += 1
                      self.bytes_remaining -= 1

                      if self.bytes_remaining == 0:
                          self.active = False

              return out_index
    packet_bytes: '53'
    tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport threading\nimport pmt\nimport time\nimport os\nfrom gnuradio import gr\n\nclass pdu_text_gui(gr.basic_block):\n    \"\"\"\n    Custom block: QT GUI Message Entry -> PDU sender with Go-Back-N ARQ.\n    NOW SUPPORTS:\n    - sync_bits : number of random bytes transmitted before each retransmission.\n    - Sync burst has NO headers, NO packetization. It is PURE RANDOM BYTE STREAM.\n    \"\"\"\n\n    def __init__(self, wait_time=2.0, pkt_size=32, address=0x01,\n                 retry_limit=100, window_size=4, sync_bits=1000):\n\n        gr.basic_block.__init__(\n            self,\n            name=\"GUI Text to PDU with Go-Back-N ARQ + Sync Burst\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # Parameters\n        self._timeout = float(wait_time)\n        self._pkt_size = int(pkt_size)\n        self._address = int(address) & 0xFF\n        self._retry_limit = int(retry_limit)\n        self._window_size = int(window_size)\n        self._sync_bits = int(sync_bits)   # NEW PARAMETER\n\n        # Seq/ACK control\n        self._seq_id = 1\n        self._last_ack_seq = 0\n        self._has_acks = False\n\n        # Register message ports\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_out(pmt.intern(\"feedback\"))\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._process_text)\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self._process_ack)\n\n        # Thread control\n        self._thread = None\n        self._stop_event = threading.Event()\n        self._lock = threading.Lock()\n\n        # Data buffers\n        self._text_data = b\"\"\n        self._packets = []\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n        self._end_seq_id = 0\n\n    # -------------------------------------------------\n    # Sync Burst Sender (PURE RANDOM BYTES)\n    # -------------------------------------------------\n    def _send_sync_burst(self):\n        if self._sync_bits <= 0:\n            return\n\n        # Pure random bytes, no header\n        sync_data = os.urandom(self._sync_bits)\n\n        vec = pmt.init_u8vector(len(sync_data), list(sync_data))\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        print(f\"[pdu_text_gui] SYNC BURST sent ({len(sync_data)} bytes)\")\n        self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n    # -------------------------------------------------\n    # Handle input text\n    # -------------------------------------------------\n    def _process_text(self, msg):\n        try:\n            if pmt.is_symbol(msg):\n                text_str = pmt.symbol_to_string(msg)\n            elif pmt.is_string(msg):\n                text_str = pmt.string_to_string(msg)\n            else:\n                print(\"[pdu_text_gui] Invalid PMT format\")\n                return\n\n            self._text_data = text_str.encode(\"utf-8\")\n\n            if self._thread is None or not self._thread.is_alive():\n                self._stop_event.clear()\n                self._thread = threading.Thread(target=self._run)\n                self._thread.daemon = True\n                self._thread.start()\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] Error processing text: {e}\")\n\n    # -------------------------------------------------\n    # Main ARQ loop\n    # -------------------------------------------------\n    def _run(self):\n        raw = self._text_data\n        step = self._pkt_size - 2\n        blocks = [raw[i:i+step] for i in range(0, len(raw), step)]\n\n        # Choose starting seq\n        if self._has_acks:\n            self._seq_id = (self._last_ack_seq + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n        else:\n            self._seq_id = 1\n\n        print(f\"[pdu_text_gui] Starting TX at seq=0x{self._seq_id:02X}\")\n\n        # Build packets\n        self._packets = []\n        for block in blocks:\n            packet = bytes([self._address, self._seq_id]) + block\n            self._packets.append((self._seq_id, packet))\n\n            self._seq_id = (self._seq_id + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n\n        # End packet\n        end_packet = bytes([self._address, self._seq_id])\n        self._packets.append((self._seq_id, end_packet))\n        self._end_seq_id = self._seq_id\n\n        print(f\"[pdu_text_gui] END packet: seq=0x{self._seq_id:02X}\")\n\n        self._seq_id = (self._seq_id + 1) & 0xFF\n        if self._seq_id == 0:\n            self._seq_id = 1\n\n        # Reset window\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n\n        # --------------------------------------------------\n        # ARQ LOOP\n        # --------------------------------------------------\n        while self._base < len(self._packets) and not self._stop_event.is_set():\n\n            # Try sending packets in window\n            with self._lock:\n                while self._next_to_send < self._base + self._window_size and \\\n                      self._next_to_send < len(self._packets):\n\n                    seq_id, packet = self._packets[self._next_to_send]\n\n                    vec = pmt.init_u8vector(len(packet), list(packet))\n                    pdu = pmt.cons(pmt.PMT_NIL, vec)\n                    self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n                    if len(packet) > 2:\n                        print(f\"[pdu_text_gui] Sent id=0x{seq_id:02X}\")\n                    else:\n                        print(f\"[pdu_text_gui] Sent END id=0x{seq_id:02X}\")\n\n                    self._next_to_send += 1\n\n            # Wait for ACK\n            time.sleep(self._timeout)\n\n            # Timeout -> Retransmit window\n            with self._lock:\n                if self._base < self._next_to_send:\n\n                    self._attempts += 1\n                    if self._attempts >= self._retry_limit:\n                        print(\"[pdu_text_gui] Retry limit exceeded\")\n                        self.message_port_pub(pmt.intern(\"feedback\"),\n                                              pmt.intern(\"RETRY_LIMIT_EXCEEDED\"))\n                        self._stop_event.set()\n                        break\n\n                    print(\"[pdu_text_gui] TIMEOUT → Sync Burst + Retransmit window\")\n\n                    # 🔥 SEND RAW SYNC BURST FIRST\n                    self._send_sync_burst()\n\n                    # retransmit packets\n                    for i in range(self._base, self._next_to_send):\n                        seq_id, packet = self._packets[i]\n\n                        vec = pmt.init_u8vector(len(packet), list(packet))\n                        pdu = pmt.cons(pmt.PMT_NIL, vec)\n                        self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n                        if len(packet) > 2:\n                            print(f\"[pdu_text_gui] Retransmit id=0x{seq_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] Retransmit END id=0x{seq_id:02X}\")\n\n    # -------------------------------------------------\n    # ACK handler\n    # -------------------------------------------------\n    def _process_ack(self, msg):\n        try:\n            payload = pmt.cdr(msg)\n            if not pmt.is_u8vector(payload):\n                return\n\n            arr = bytearray(pmt.u8vector_elements(payload))\n            if len(arr) < 2:\n                return\n            if arr[0] != 0xAA:\n                return\n\n            ack_id = arr[1]\n\n            with self._lock:\n                for i in range(self._base, self._next_to_send):\n                    seq_id, _ = self._packets[i]\n\n                    if seq_id == ack_id:\n                        self._has_acks = True\n                        self._last_ack_seq = ack_id\n\n                        if len(self._packets[i][1]) > 2:\n                            print(f\"[pdu_text_gui] ACK for 0x{ack_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] ACK END 0x{ack_id:02X}\")\n                            self.message_port_pub(pmt.intern(\"feedback\"),\n                                                  pmt.intern(\"END_ACK_RECEIVED\"))\n\n                        self._base = i + 1\n                        self._attempts = 0\n                        break\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] ACK error: {e}\")\n\n"
    address: '50'
    pkt_size: '100'
    retry_limit: '100'
    sync_bits: 1e4
    wait_time: '0.1'
    window_size: '7'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Idle + Packet Injector
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Continuous stream block with idle bytes 0xAA.
          Injects packets from input stream (Tagged Stream Mux) whenever available.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              print(inp)

              n_out = len(out)
              in_len = len(inp)
              out_index = 0


              # ---- Append input bytes to internal buffer ----
              if in_len > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Fill output ----
              while out_index < n_out:

                  if len(self.packet_buffer) > 0:
                      # Pop from buffer
                      out[out_index] = self.packet_buffer.pop(0)
                  else:
                      # Output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Idle + Packet Injector
          Waits until the full packet (according to header length) is received before transmitting.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []
              self.expected_length = None  # Total packet length including header

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n_out = len(out)
              out_index = 0

              # ---- Append input bytes to internal buffer ----
              if len(inp) > 0:
                  self.packet_buffer.extend(inp.tolist())


              # ---- Extract expected packet length from header ----
              # Header format: XX XX XX XX 00 <length_byte> 00 <length_byte>
              if self.expected_length is None and len(self.packet_buffer) >= 6:
                  length_byte = self.packet_buffer[5]  # 0-based index for first length byte
                  self.expected_length = 8 + length_byte  # 8-byte header + payload

              # ---- Fill output ----
              while out_index < n_out:
                  if self.expected_length is not None and len(self.packet_buffer) >= self.expected_length:
                      # Full packet ready: transmit first byte
                      out[out_index] = self.packet_buffer.pop(0)
                      # If entire packet transmitted, reset expected_length
                      if len(self.packet_buffer) == 0:
                          self.expected_length = None
                  else:
                      # Not enough bytes yet: output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class IdlePacketInjectorWithLength(gr.sync_block):
          """
          Idle + Packet Injector (robust version)
          - Continuously outputs idle bytes until a full packet is buffered.
          - Transmits the entire packet (with payload-length byte first) once ready.
          - Supports back-to-back packets in the buffer.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjectorWithLength",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []
              self.expected_length = None  # total length including header
              self.payload_length = None
              self.send_length_byte = False
              self.sentcount = 0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out_index = 0

              # ---- Append new bytes to internal buffer ----
              if len(inp) > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Process output buffer ----
              while out_index < n_out:

                  # ---- Check if a full packet is available ----
                  if self.expected_length is None and len(self.packet_buffer) >= 6:
                      # Extract payload length from header
                      self.payload_length = self.packet_buffer[5]  # 0-based index
                      self.expected_length = 8 + self.payload_length
                      self.send_length_byte = True
                      self.sentcount = 0

                  # ---- If full packet is ready, transmit it ----
                  if self.expected_length is not None and len(self.packet_buffer) >= self.expected_length:
                      if self.send_length_byte:
                          # Send payload-length byte first
                          out[out_index] = self.payload_length
                          self.send_length_byte = False
                          out_index += 1
                          continue  # continue without incrementing out_index again
                      else:
                          # Send packet bytes
                          out[out_index] = self.packet_buffer.pop(0)
                          print(out[out_index])
                          self.sentcount += 1

                          # Check if packet transmission is complete
                          if self.sentcount >= self.payload_length:
                              # Remove header bytes as well
                              for _ in range(8):
                                  if self.packet_buffer:
                                      self.packet_buffer.pop(0)
                              # Reset state for next packet
                              self.expected_length = None
                              self.payload_length = None
                              self.send_length_byte = False
                              self.sentcount = 0
                  else:
                      # Not enough bytes: send idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, address=1, max_packet_size=32):  # Receiver address + packet size
              gr.basic_block.__init__(
                  self,
                  name="pdu_deduplicator",
                  in_sig=[],
                  out_sig=[]
              )

              self.address = int(address) & 0xFF
              self.max_packet_size = int(max_packet_size)

              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_out(pmt.intern("ack_packet_out"))

              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_pdu)

              self.seen_packets = set()

          def reset_sequence(self):
              """Resets deduplication state after receiving termination packet."""
              print("[Deduplicator] Resetting sequence state.")
              self.seen_packets = set()

          def handle_pdu(self, msg):

              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  print("[Deduplicator] Invalid data type.")
                  return

              byte_data = bytearray(pmt.u8vector_elements(data))

              if len(byte_data) < 3:
                  print("[Deduplicator] Packet too short.")
                  return

              src_addr = byte_data[0]
              dest_addr = byte_data[1]
              pkt_num = byte_data[2]

              # Only accept packets addressed to me
              if dest_addr != self.address:
                  return

              # ---------------------------------------------------------
              #  CHECK FOR TERMINATION PACKET
              # ---------------------------------------------------------
              expected_term_length = self.max_packet_size + 1

              if len(byte_data) == expected_term_length:
                  # termination payload = all 0xFF bytes
                  payload = byte_data[3:]
                  if all(b == 0xFF for b in payload):

                      print(f"[Deduplicator] Termination packet #{pkt_num:02X} received. Sending ACK & resetting.")

                      # Send ACK (same mechanism as normal)
                      ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])
                      ack_pdu = pmt.cons(pmt.make_dict(),
                                         pmt.init_u8vector(len(ack_packet), list(ack_packet)))

                      for _ in range(80):
                          self.message_port_pub(pmt.intern("ack_packet_out"), ack_pdu)

                      # Reset deduplication for next message
                      self.reset_sequence()

                      # DO NOT forward termination packet
                      return

              # ---------------------------------------------------------
              #  NORMAL PACKET HANDLING
              # ---------------------------------------------------------

              # Duplicate check
              if pkt_num in self.seen_packets:
                  print(f"[Deduplicator] Duplicate packet #{pkt_num:02X} discarded.")
                  return

              self.seen_packets.add(pkt_num)

              # Forward stripped payload (remove src,dest,pktnum)
              stripped_payload = byte_data[3:]
              payload = pmt.init_u8vector(len(stripped_payload), list(stripped_payload))
              pdu = pmt.cons(pmt.make_dict(), payload)
              self.message_port_pub(pmt.intern("pdus_out"), pdu)

              # Send ACK
              ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])
              ack_pdu = pmt.cons(pmt.make_dict(),
                                 pmt.init_u8vector(len(ack_packet), list(ack_packet)))

              print("[Deduplicator] Sending ACK...")
              for _ in range(80):
                  self.message_port_pub(pmt.intern("ack_packet_out"), ack_pdu)

              print(f"[Deduplicator] Accepted packet #{pkt_num:02X} from {src_addr:02X}. Sent ACK.")
    address: '2'
    max_packet_size: '32'
  states: {state: disabled}
- name: epy_block_3_3
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, address=1, max_packet_size=32):\n        gr.basic_block.__init__(\n            self,\n            name=\"pdu_deduplicator\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.address = int(address) & 0xFF\n        self.max_packet_size = int(max_packet_size)\n\n        self.message_port_register_in(pmt.intern(\"pdus_in\"))\n        self.message_port_register_out(pmt.intern(\"pdus_out\"))\n        self.message_port_register_out(pmt.intern(\"ack_packet_out\"))\n\n        self.set_msg_handler(pmt.intern(\"pdus_in\"), self.handle_pdu)\n\n        self.seen_packets = set()\n\n        # ---------------------------------------------------\n        # NEW: State for ACK forwarding\n        # ---------------------------------------------------\n        self.last_ack_forwarded = None\n        self.expected_ack_pkt = 0\n\n    def reset_sequence(self):\n        print(\"[Deduplicator] Resetting sequence state.\")\n        self.seen_packets = set()\n        self.last_ack_forwarded = None\n        self.expected_ack_pkt = 0\n\n    def handle_pdu(self, msg):\n        data = pmt.cdr(msg)\n\n        if not pmt.is_u8vector(data):\n            print(\"[Deduplicator] Invalid data type.\")\n            return\n\n        byte_data = bytearray(pmt.u8vector_elements(data))\n\n        if len(byte_data) < 3:\n            print(\"[Deduplicator] Packet too short.\")\n            return\n\n        src_addr = byte_data[0]\n        dest_addr = byte_data[1]\n        pkt_num = byte_data[2]\n\n        # ===========================================================\n        # NEW: Detect ACK packet coming *from transmitter*\n        # ===========================================================\n        if byte_data[0] == 0xAA:\n            ack_src = byte_data[1]\n            ack_dest = byte_data[2]\n            ack_num = byte_data[3]\n\n            # Check if ACK is expected\n            if ack_num == self.expected_ack_pkt:\n\n                # avoid forwarding duplicates\n                if self.last_ack_forwarded != ack_num:\n                    print(f\"[Deduplicator] Forwarding expected ACK #{ack_num:02X}.\")\n                    ack_pdu = pmt.cons(\n                        pmt.make_dict(),\n                        pmt.init_u8vector(len(byte_data), list(byte_data))\n                    )\n                    self.message_port_pub(pmt.intern(\"pdus_out\"), ack_pdu)\n                    self.last_ack_forwarded = ack_num\n\n                    # next expected ACK\n                    self.expected_ack_pkt += 1\n\n                else:\n                    print(f\"[Deduplicator] Duplicate expected ACK #{ack_num:02X} ignored.\")\n\n            else:\n                print(f\"[Deduplicator] Unexpected ACK #{ack_num:02X} discarded.\")\n\n            return\n        # ===========================================================\n\n\n        if dest_addr != self.address:\n            return\n\n        expected_term_length = self.max_packet_size + 1\n\n        # ---------------------------------------------------------\n        # TERMINATION PACKET\n        # ---------------------------------------------------------\n        if len(byte_data) == expected_term_length:\n            payload = byte_data[3:]\n            if all(b == 0xFF for b in payload):\n\n                print(f\"[Deduplicator] Termination packet #{pkt_num:02X} received.\")\n\n                # ---- Send ACK ----\n                ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])\n                ack_pdu = pmt.cons(pmt.make_dict(),\n                                   pmt.init_u8vector(len(ack_packet), list(ack_packet)))\n\n                #for _ in range(80):\n                self.message_port_pub(pmt.intern(\"ack_packet_out\"), ack_pdu)\n\n                # ---- Forward termination to next block ----\n                forward_bytes = bytes([pkt_num]) + byte_data[3:]  # pkt_num + all FFs\n                payload_pdu = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n                out = pmt.cons(pmt.make_dict(), payload_pdu)\n                self.message_port_pub(pmt.intern(\"pdus_out\"), out)\n\n                # ---- Reset dedup ----\n                self.reset_sequence()\n\n                return\n\n        # ---------------------------------------------------------\n        # NORMAL PACKET\n        # ---------------------------------------------------------\n        if pkt_num in self.seen_packets:\n            print(f\"[Deduplicator] Duplicate packet #{pkt_num:02X} discarded.\")\n            return\n\n        self.seen_packets.add(pkt_num)\n\n        forward_bytes = bytes([pkt_num]) + byte_data[3:]\n        payload = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n        out_pdu = pmt.cons(pmt.make_dict(), payload)\n        self.message_port_pub(pmt.intern(\"pdus_out\"), out_pdu)\n\n        # ACK\n        ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])\n        ack_pdu = pmt.cons(pmt.make_dict(),\n                           pmt.init_u8vector(len(ack_packet), list(ack_packet)))\n\n        \n        self.message_port_pub(pmt.intern(\"ack_packet_out\"), ack_pdu)\n\n        print(f\"[Deduplicator] Accepted packet #{pkt_num:02X}.\")\n\n"
    address: '2'
    max_packet_size: '32'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    \"\"\"\n    PDU Prepend Pattern Bytes (fast & PMT-compatible)\n\n    - Prepends a fixed byte pattern to each incoming PDU.\n    - Avoids expensive per-PDU slicing by precomputing pattern chunks.\n    \"\"\"\n\n    def __init__(self, num_bytes=4):\n        gr.basic_block.__init__(\n            self,\n            name=\"PDU Prepend Pattern Bytes\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.num_bytes = int(num_bytes)\n\n        # ----------------------------------------------------\n        # Pre-generated pattern: 8-byte sequence repeated\n        # Convert immediately to list[int] for fast concatenation\n        # ----------------------------------------------------\n        base = bytes.fromhex(\"12 34 56 78 9A BC DE F0\")\n        self.pattern_bytes = list(base * ((self.num_bytes // len(base)) + 1))\n        # Keep only exactly num_bytes length\n        self.pattern_bytes = self.pattern_bytes[:self.num_bytes]\n\n        # ----------------------------------------------------\n        # Message ports\n        # ----------------------------------------------------\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n    def handle_msg(self, msg):\n        meta = pmt.car(msg)\n        vec = pmt.cdr(msg)\n\n        # Convert incoming payload to list[int] for PMT\n        payload_list = list(pmt.u8vector_elements(vec))\n\n        # Concatenate pattern + payload (list of ints)\n        out_list = self.pattern_bytes + payload_list\n\n        # Create PMT u8vector\n        out_vec = pmt.init_u8vector(len(out_list), out_list)\n\n        # Publish new PDU\n        self.message_port_pub(\n            pmt.intern(\"out\"),\n            pmt.cons(meta, out_vec)\n        )\n\n"
    num_bytes: '10000'
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Idle + Packet Injector
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Continuous stream block with idle bytes 0xAA.
          Injects packets from input stream (Tagged Stream Mux) whenever available.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n_out = len(out)
              in_len = len(inp)
              out_index = 0

              # ---- Append input bytes to internal buffer ----
              if in_len > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Fill output ----
              while out_index < n_out:

                  if len(self.packet_buffer) > 0:
                      # Pop from buffer
                      out[out_index] = self.packet_buffer.pop(0)
                  else:
                      # Output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class dump_hex(gr.sync_block):
          """
          Prints bytes in hex format.
          """
          def __init__(self, label="HEX"):
              gr.sync_block.__init__(
                  self,
                  name="DumpHex",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.label = label

          def work(self, input_items, output_items):
              inp = input_items[0]

              hex_str = " ".join([f"{b:02X}" for b in inp])
              print(f"{self.label}: {hex_str}")

              return len(inp)
    label: '''HEX'''
  states: {state: disabled}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class dump_hex(gr.sync_block):
          """
          Prints bytes in hex format.
          """
          def __init__(self, label="HEX"):
              gr.sync_block.__init__(
                  self,
                  name="DumpHex",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.label = label

          def work(self, input_items, output_items):
              inp = input_items[0]

              hex_str = " ".join([f"{b:02X}" for b in inp])
              print(f"{self.label}: {hex_str}")

              return len(inp)
    label: '''HEX'''
  states: {state: disabled}
- name: epy_block_5_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class TaggedPayloadExtractor(gr.sync_block):
          """
          Tag-based payload extractor.
          - Waits for a tag with name `tag_key`.
          - Reads the first byte after the tag as payload length.
          - Forwards exactly that many bytes.
          - Discards anything else until next tag.
          """
          def __init__(self, tag_key="packet_start"):
              gr.sync_block.__init__(
                  self,
                  name="TaggedPayloadExtractor",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_key)
              self.active = False
              self.bytes_remaining = 0
              self.length_byte_read = False


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)
              out_index = 0
              consumed = 0

              print(inp)

              # ---- Check for tags in current window ----
              tags = self.get_tags_in_window(0, 0, n_in)
              for t in tags:
                  if t.key == self.tag_key:
                      self.active = True
                      self.bytes_remaining = 0
                      self.length_byte_read = False

              # ---- Process input bytes ----
              for i in range(n_in):
                  if self.active:
                      if not self.length_byte_read:
                          # First byte after tag = payload length
                          self.bytes_remaining = inp[i]
                          self.length_byte_read = True
                          consumed+=1


                      elif self.bytes_remaining > 0:
                          if out_index < len(out):
                              out[out_index] = inp[i]
                              out_index += 1
                              consumed+=1
                              self.bytes_remaining -= 1
                              if self.bytes_remaining == 0:
                                  # Packet done, wait for next tag
                                  self.active = False
                                  self.length_byte_read = False

              return consumed
              #return n_in
    tag_key: '''packet_len'''
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from collections import deque

      class IdlePacketInjectorExact(gr.sync_block):
          """
          IdlePacketInjectorExact
          - Idle byte (0xAA) is output continuously until a full packet is buffered.
          - Packet format expected in rx stream: 8-byte header (header[5] = payload_len) followed by payload_len bytes.
          - When full packet is available, transmit exactly:
               [header0..7][payload_len][payload_bytes]
            (i.e., transmit the packet exactly as received)
          - Transmission is continuous at the normal flow rate; packets may span multiple work() calls.
          - While transmitting a packet, rx_buf continues to accumulate the next incoming packet.
          """

          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjectorExact",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte & 0xFF

              # rx_buf: collects incoming raw bytes (deque for O(1) pops/appends)
              self.rx_buf = deque()
              # tx_buf: bytes of the packet currently being transmitted (deque)
              self.tx_buf = deque()

              # state helpers
              self.waiting_for_full_packet = True  # True when looking to form next tx_buf from rx_buf

          def _try_make_packet(self):
              """
              If rx_buf contains at least 8 bytes, read header[5] to get payload length,
              and if rx_buf contains the full packet (8 + payload_len), move those bytes
              to tx_buf (only if tx_buf is currently empty so we keep single active tx buffer).
              """
              # Only create a new tx packet if nothing is currently transmitting
              if self.tx_buf:
                  return

              # Need at least 6 bytes to read header[5] safely (indexes 0..5)
              if len(self.rx_buf) < 6:
                  return

              # Peek header[5] without popping
              # Convert deque to indexing by iterating - deque supports indexing but it's O(n).
              # Access small index directly via tuple() for efficiency when len small
              # but for clarity just use indexing (acceptable because index 5).
              payload_len = self.rx_buf[5]

              total_len = 8 + int(payload_len)  # 8-byte header + payload_len bytes

              # If we have full packet in rx_buf, move it to tx_buf
              if len(self.rx_buf) >= total_len:
                  # move the first total_len bytes from rx_buf to tx_buf in order
                  for _ in range(total_len):
                      self.tx_buf.append(self.rx_buf.popleft())

                  # Now tx_buf contains [header0..7, payload...], and will be transmitted
                  # We don't set any special flag; presence of tx_buf indicates active transmission

      # assume total_len = header_len + payload_len
                  #header = [self.rx_buf.popleft() for _ in range(8)]  # first 8 bytes of header
                  #payload = [self.rx_buf.popleft() for _ in range(total_len - 8)]  # rest of packet

      # insert payload length byte right after header
                  #payload_len_byte = total_len - 8
                  #self.tx_buf.extend(header)         # header bytes
                  #self.tx_buf.append(payload_len)  # length byte
                  #self.tx_buf.extend(payload)        # payload bytes
                  #print(self.tx_buf)


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out_index = 0

              # 1) append incoming bytes to rx_buf
              if len(inp) > 0:
                  # inp is a numpy array of uint8
                  self.rx_buf.extend(int(b) for b in inp.tolist())

              # 2) if no active tx_buf, try to assemble a packet from rx_buf
              # This also ensures back-to-back packets are handled: after finishing one,
              # next will be immediately prepared if rx_buf already contains it.
              self._try_make_packet()

              # 3) fill the output buffer at full rate.
              #    If tx_buf has data -> stream it continuously until empty,
              #    otherwise send idle bytes.
              while out_index < n_out:
                  if self.tx_buf:
                      # transmit next byte of current packet
                      out[out_index] = self.tx_buf.popleft()
                      out_index += 1

                      # after popping a byte, if tx_buf becomes empty, attempt to prepare next packet
                      if not self.tx_buf:
                          # attempt to build the next packet immediately (back-to-back)
                          self._try_make_packet()
                      # continue loop
                  else:
                      # no packet currently being transmitted -> output idle
                      out[out_index] = self.idle_byte
                      out_index += 1

                      # also after sending idle we can check if rx_buf now contains a full packet
                      # (useful if rx_buf filled during this work() call)
                      # But avoid calling _try_make_packet too often; it's cheap so ok:
                      self._try_make_packet()

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore\nimport sys\nimport datetime\n\nclass MessageBubble(QtWidgets.QWidget):\n    def __init__(self, text, time_str, parent=None):\n        super().__init__(parent)\n        layout = QtWidgets.QHBoxLayout()\n        layout.setContentsMargins(0, 5, 0, 5)\n\n        frame = QtWidgets.QFrame()\n        frame_layout = QtWidgets.QVBoxLayout(frame)\n\n        frame.setStyleSheet(\"\"\"\n            QFrame {\n                background-color: white;\n                border-radius: 10px;\n                border: 1px solid #CCCCCC;\n            }\n        \"\"\")\n\n        lbl_text = QtWidgets.QLabel(text)\n        lbl_text.setWordWrap(True)\n        lbl_text.setStyleSheet(\"font-size: 14px; color: black;\")\n        frame_layout.addWidget(lbl_text)\n\n        meta = QtWidgets.QHBoxLayout()\n        lbl_time = QtWidgets.QLabel(time_str)\n        lbl_time.setStyleSheet(\"font-size: 10px; color: #555;\")\n        meta.addStretch()\n        meta.addWidget(lbl_time)\n        frame_layout.addLayout(meta)\n\n        layout.addWidget(frame)\n        layout.addStretch()\n        self.setLayout(layout)\n\n\nclass ChatReceiverWindow(QtWidgets.QWidget):\n    new_message_signal = QtCore.pyqtSignal(str)\n\n    def __init__(self):\n        super().__init__()\n        self.setWindowTitle(\"Received Messages\")\n        self.resize(400, 600)\n        self.setStyleSheet(\"background-color: #E6EBEF;\")\n\n        layout = QtWidgets.QVBoxLayout()\n        self.chat_area = QtWidgets.QListWidget()\n        self.chat_area.setStyleSheet(\"border: none; background-color: transparent;\")\n        layout.addWidget(self.chat_area)\n        self.setLayout(layout)\n\n        self.new_message_signal.connect(self.display)\n\n    def display(self, text):\n        time_str = datetime.datetime.now().strftime(\"%H:%M\")\n        bubble = MessageBubble(text, time_str)\n        item = QtWidgets.QListWidgetItem()\n        item.setSizeHint(bubble.sizeHint())\n        self.chat_area.addItem(item)\n        self.chat_area.setItemWidget(item, bubble)\n        self.chat_area.scrollToBottom()\n\n\nclass ChatReceiverInterface(gr.basic_block):\n\n    def __init__(self, max_packet_size=32):\n        gr.basic_block.__init__(\n            self,\n            name=\"Chat Receiver Interface GUI\",\n            in_sig=None,\n            out_sig=None)\n\n        self.max_packet_size = int(max_packet_size)\n\n        self.message_port_register_in(pmt.intern(\"pdus_in\"))\n        self.set_msg_handler(pmt.intern(\"pdus_in\"), self.handle_pdu)\n\n        self.qapp = QtWidgets.QApplication.instance()\n        if not self.qapp:\n            self.qapp = QtWidgets.QApplication(sys.argv)\n\n        self.gui = ChatReceiverWindow()\n        self.gui.show()\n\n        self.buffer = {}   # pkt_num → pdu\n\n    def handle_pdu(self, pdu):\n        meta = pmt.car(pdu)\n        vec = pmt.cdr(pdu)\n\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = list(pmt.u8vector_elements(vec))\n        pkt_len = len(data)\n        pkt_num = data[0]\n\n        print(f\"[RX] Received PDU (len={pkt_len}) pkt={pkt_num}\")\n\n        # ------------------------------------------------------\n        # TERMINATION PACKET\n        # ------------------------------------------------------\n        if pkt_len == self.max_packet_size - 1:\n            print(\"[RX] Termination packet detected.\")\n\n            full_bytes = b\"\"\n\n            for k in sorted(self.buffer.keys()):\n                p = self.buffer[k]\n                raw = list(pmt.u8vector_elements(pmt.cdr(p)))\n                full_bytes += bytes(raw[1:])  # skip pkt_num\n\n            try:\n                decoded = full_bytes.decode(\"utf-8\")\n            except:\n                decoded = \"<Decode Error>\"\n\n            # ----------- ADDED CONDITION HERE --------------\n            if decoded.strip() == \"\":\n                print(\"[RX] Empty message. Not displaying.\")\n            else:\n                self.gui.new_message_signal.emit(decoded)\n                print(\"[RX] Assembled message:\", decoded)\n            # ------------------------------------------------\n\n            self.buffer.clear()\n            return\n\n        # ------------------------------------------\n        # NORMAL PACKET\n        # ------------------------------------------\n        self.buffer[pkt_num] = pdu\n        print(f\"[RX] Stored packet {pkt_num}\")\n\n    def stop(self):\n        self.gui.close()\n        return super().stop()\n\n"
    max_packet_size: '32'
  states: {state: disabled}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import datetime

      class MessageBubble(QtWidgets.QWidget):
          """A custom widget to render a message bubble"""
          def __init__(self, text, time_str, status="Waiting", parent=None):
              super().__init__(parent)
              self.layout = QtWidgets.QHBoxLayout()
              self.layout.setContentsMargins(0, 5, 0, 5)

              self.container = QtWidgets.QFrame()
              self.container_layout = QtWidgets.QVBoxLayout()
              self.container.setLayout(self.container_layout)
              
              self.container.setStyleSheet("""
                  QFrame {
                      background-color: #EEFFDD; 
                      border-radius: 10px;
                      border: 1px solid #CCDDCC;
                  }
              """)

              self.lbl_text = QtWidgets.QLabel(text)
              self.lbl_text.setWordWrap(True)
              self.lbl_text.setStyleSheet("border: none; font-size: 14px; color: black;")
              self.container_layout.addWidget(self.lbl_text)

              self.meta_layout = QtWidgets.QHBoxLayout()
              self.lbl_time = QtWidgets.QLabel(time_str)
              self.lbl_time.setStyleSheet("border: none; font-size: 10px; color: #555;")
              
              self.lbl_status = QtWidgets.QLabel(status)
              self.lbl_status.setStyleSheet("border: none; font-size: 10px; font-weight: bold; color: gray;")
              
              self.meta_layout.addStretch()
              self.meta_layout.addWidget(self.lbl_time)
              self.meta_layout.addWidget(self.lbl_status)
              self.container_layout.addLayout(self.meta_layout)

              self.layout.addStretch()
              self.layout.addWidget(self.container)
              self.setLayout(self.layout)

          def set_status(self, status, color):
              self.lbl_status.setText(status)
              self.lbl_status.setStyleSheet(f"border: none; font-size: 10px; font-weight: bold; color: {color};")
              if status == "Failed":
                   self.container.setStyleSheet("QFrame { background-color: #FFDDDD; border-radius: 10px; border: 1px solid #DDAAAA; }")
              elif "Sent" in status:
                   self.container.setStyleSheet("QFrame { background-color: #EEFFDD; border-radius: 10px; border: 1px solid #CCDDCC; }")

      class ChatWindow(QtWidgets.QWidget):
          """The Telegram-style Window"""
          send_signal = QtCore.pyqtSignal(str)
          # NEW: Internal signal for thread-safe updates
          status_signal = QtCore.pyqtSignal(str, str) 

          def __init__(self):
              super().__init__()
              self.setWindowTitle("Secure Radio Chat")
              self.resize(400, 600)
              self.setStyleSheet("background-color: #E6EBEF;")

              layout = QtWidgets.QVBoxLayout()

              self.chat_area = QtWidgets.QListWidget()
              self.chat_area.setStyleSheet("border: none; background-color: transparent;")
              self.chat_area.setSelectionMode(QtWidgets.QAbstractItemView.NoSelection)
              self.chat_area.setVerticalScrollMode(QtWidgets.QAbstractItemView.ScrollPerPixel)
              layout.addWidget(self.chat_area)

              input_container = QtWidgets.QWidget()
              input_container.setStyleSheet("background-color: white; border-top: 1px solid #DDD;")
              input_layout = QtWidgets.QHBoxLayout()
              input_container.setLayout(input_layout)

              self.text_input = QtWidgets.QLineEdit()
              self.text_input.setPlaceholderText("Write a message...")
              self.text_input.returnPressed.connect(self.on_send)
              input_layout.addWidget(self.text_input)

              self.send_btn = QtWidgets.QPushButton("➤") 
              self.send_btn.setFixedSize(40, 40)
              self.send_btn.setStyleSheet("background-color: #3390EC; color: white; border-radius: 20px; font-weight: bold;")
              self.send_btn.clicked.connect(self.on_send)
              input_layout.addWidget(self.send_btn)

              layout.addWidget(input_container)
              self.setLayout(layout)

              self.current_bubble = None
              
              # Connect the signal to the update function
              self.status_signal.connect(self.update_last_status)

          def on_send(self):
              text = self.text_input.text().strip()
              if text:
                  self.text_input.clear()
                  time_str = datetime.datetime.now().strftime("%H:%M")
                  self.current_bubble = MessageBubble(text, time_str, "Sending...")
                  
                  item = QtWidgets.QListWidgetItem()
                  item.setSizeHint(self.current_bubble.sizeHint())
                  self.chat_area.addItem(item)
                  self.chat_area.setItemWidget(item, self.current_bubble)
                  self.chat_area.scrollToBottom()

                  self.send_signal.emit(text)

          def update_last_status(self, text, color):
              if self.current_bubble:
                  self.current_bubble.set_status(text, color)

      class ChatInterface(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Chat Interface (Telegram Style)",
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern("msg_out"))
              self.message_port_register_in(pmt.intern("status_in"))
              self.set_msg_handler(pmt.intern("status_in"), self.handle_status)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.gui = ChatWindow()
              self.gui.send_signal.connect(self.send_message)
              self.gui.show()

          def send_message(self, text):
              msg = pmt.intern(text)
              self.message_port_pub(pmt.intern("msg_out"), msg)

          def handle_status(self, msg):
              """Receives status updates from Block 2"""
              try:
                  status_str = pmt.symbol_to_string(msg)
                  
                  # DEBUG PRINT: Check if this appears in your GRC console!
                  print(f"[GUI] Status received: '{status_str}'")

                  if status_str == "success":
                      # Use signal to update GUI safely
                      self.gui.status_signal.emit("✓ Sent", "#3390EC")
                  elif status_str == "fail":
                      self.gui.status_signal.emit("Failed", "red")
                  elif status_str == "pending":
                      pass

              except Exception as e:
                  print(f"[GUI] Error handling status: {e}")

          def stop(self):
              self.gui.close()
              return super().stop()
  states: {state: disabled}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import threading
      import time
      from gnuradio import gr

      class TextToPDU_ARQ(gr.basic_block):
          def __init__(self, max_packet_size=32, src_address=1, dest_address=2):
              gr.basic_block.__init__(
                  self,
                  name="Text to PDU (ARQ Logic)",
                  in_sig=[],
                  out_sig=[]
              )
              
              # --- CONFIGURATION (USER SETTABLE) ---
              self.interval = 0.5
              self.max_packet_size = int(max_packet_size)
              self.src_address = int(src_address) & 0xFF
              self.dest_address = int(dest_address) & 0xFF
              # -------------------------------------

              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_in(pmt.intern("ack_bits"))
              self.set_msg_handler(pmt.intern("ack_bits"), self.handle_ack_bits)

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_input)
              self.message_port_register_out(pmt.intern("status_out"))

              self._stop_event = threading.Event()
              self._ack_event = threading.Event()
              self._ack_lock = threading.Lock()
              self._expected_ack = None
              self._tx_lock = threading.Lock()  # Prevent overlapping transmissions

          def stop(self):
              self._stop_event.set()
              self._ack_event.set()
              return super().stop()

          def handle_msg_input(self, msg):
              text_data = pmt.symbol_to_string(msg)
              
              if self._tx_lock.locked():
                  #print("[ARQ] Busy sending previous message.")
                  return

              t = threading.Thread(target=self._process_transmission, args=(text_data,))
              t.daemon = True
              t.start()

          def _process_transmission(self, text_data):
              with self._tx_lock:
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("pending"))
                  
                  data = text_data.encode('utf-8')
                  chunk_size = self.max_packet_size - 3
                  chunks = [data[i:i + chunk_size] for i in range(0, len(data), chunk_size)]

                  packet_number = 1
                  success = True

                  # --- SEND ALL NORMAL PACKETS ---
                  for chunk in chunks:
                      if self._stop_event.is_set():
                          success = False
                          break

                      full_packet = bytes([self.src_address, self.dest_address, packet_number]) + chunk
                      payload = pmt.init_u8vector(len(full_packet), list(full_packet))
                      pdu = pmt.cons(pmt.make_dict(), payload)

                      with self._ack_lock:
                          self._expected_ack = packet_number
                          self._ack_event.clear()

                      retry_count = 0
                      max_retries = 200
                      chunk_sent_successfully = False

                      while not self._stop_event.is_set() and retry_count < max_retries:
                          self.message_port_pub(pmt.intern("pdus"), pdu)

                          ack_received = self._ack_event.wait(timeout=self.interval)
                          if ack_received:
                              chunk_sent_successfully = True
                              break
                          else:
                              #print(f"[ARQ] Timeout waiting for ACK #{packet_number:02X}")
                              retry_count += 1

                      if not chunk_sent_successfully:
                          print(f"[ARQ] Failed to send packet #{packet_number:02X}")
                          success = False
                          break

                      packet_number = (packet_number + 1) & 0xFF
                      if packet_number == 0x00:
                          packet_number = 0x01

                  # ============================================================
                  # --- SEND TERMINATION PACKET ---
                  # ============================================================
                  if success and not self._stop_event.is_set():
                      term_packet_number = packet_number  # use next sequence

                      # termination payload size so TOTAL packet = max_packet_size + 1
                      term_payload_len = (self.max_packet_size + 1) - 3
                      term_payload = bytes([0xFF] * term_payload_len)

                      full_packet = bytes([
                          self.src_address,
                          self.dest_address,
                          term_packet_number
                      ]) + term_payload

                      payload = pmt.init_u8vector(len(full_packet), list(full_packet))
                      pdu = pmt.cons(pmt.make_dict(), payload)

                      with self._ack_lock:
                          self._expected_ack = term_packet_number
                          self._ack_event.clear()

                      retry_count = 0
                      max_retries = 200
                      term_success = False

                      while not self._stop_event.is_set() and retry_count < max_retries:
                          self.message_port_pub(pmt.intern("pdus"), pdu)

                          ack_received = self._ack_event.wait(timeout=self.interval)
                          if ack_received:
                              term_success = True
                              break
                          else:
                              print(f"[ARQ] Timeout waiting for TERMINATION ACK #{term_packet_number:02X}")
                              retry_count += 1

                      if not term_success:
                          print(f"[ARQ] Failed to send TERMINATION packet #{term_packet_number:02X}")
                          success = False

                  # ============================================================

                  if success:
                      print("[ARQ] Transmission Success. Updating GUI.")
                      self.message_port_pub(pmt.intern("status_out"), pmt.intern("success"))
                  else:
                      print("[ARQ] Transmission Failed. Updating GUI.")
                      self.message_port_pub(pmt.intern("status_out"), pmt.intern("fail"))

          def handle_ack_bits(self, msg):
              try:
                  data = pmt.cdr(msg)
                  if not pmt.is_u8vector(data):
                      return

                  byte_data = bytearray(pmt.u8vector_elements(data))
                  if len(byte_data) < 4:
                      return
                  
                  if byte_data[0] != 0xAA:
                      return

                  ack_src_addr = byte_data[1]
                  ack_dest_addr = byte_data[2]
                  ack_packet_num = byte_data[3]

                  if ack_dest_addr != self.src_address:
                      return
                  if ack_src_addr != self.dest_address:
                      return

                  with self._ack_lock:
                      if ack_packet_num == self._expected_ack:
                          print(f"[ARQ] Valid ACK received for #{ack_packet_num:02X}")
                          self._ack_event.set()
                          
              except Exception as e:
                  print(f"[ARQ] Error handling ACK: {str(e)}")
    dest_address: '2'
    max_packet_size: '32'
    src_address: '1'
  states: {state: disabled}
- name: epy_block_9_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class blk(gr.basic_block):  # Inherit from basic_block for Message passing
          """Text to PDU (Blind Repeater) - Interval in Seconds"""

          def __init__(self, preamble_len=10000, repeat_count=5, repeat_interval_seconds=1.0, src_address=1, dest_address=2):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Text to PDU (Blind Repeater)',   # will show up in GRC
                  in_sig=None,   # No streaming inputs
                  out_sig=None   # No streaming outputs
              )
              
              # --- Parameters ---
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              
              # This value is treated as SECONDS (e.g., 1.0 = 1 second, 0.5 = 500ms)
              self.repeat_interval = float(repeat_interval_seconds) 
              
              self.src_address = int(src_address) & 0xFF
              self.dest_address = int(dest_address) & 0xFF

              # --- Message Ports ---
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_input)

              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("status_out"))

              # Threading lock
              self._tx_lock = threading.Lock()

          def handle_msg_input(self, msg):
              """Handler for incoming text messages from GUI"""
              try:
                  text_data = pmt.symbol_to_string(msg)
              except:
                  print("[BlindTx] Error: Input must be a string symbol")
                  return

              if self._tx_lock.locked():
                  print("[BlindTx] Busy sending previous message.")
                  return

              t = threading.Thread(target=self._process_transmission, args=(text_data,))
              t.daemon = True
              t.start()

          def _process_transmission(self, text_data):
              """Constructs packet and repeats it with user-defined interval in seconds"""
              with self._tx_lock:
                  # Update GUI status
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("pending"))
                  
                  # --- CONSTRUCT THE PACKET ---
                  preamble = bytes([0xAA] * self.preamble_len)
                  header = bytes([self.src_address, self.dest_address, 0x01])
                  payload = text_data.encode('utf-8')
                  
                  full_data = preamble + header + payload
                  
                  pdu_vector = pmt.init_u8vector(len(full_data), list(full_data))
                  pdu = pmt.cons(pmt.make_dict(), pdu_vector)

                  print(f"[BlindTx] Sending {len(full_data)} bytes. Repeats: {self.repeat_count}, Interval: {self.repeat_interval}s")

                  # --- SEND LOOP ---
                  for i in range(self.repeat_count):
                      self.message_port_pub(pmt.intern("pdus"), pdu)
                      
                      # Sleep in SECONDS
                      time.sleep(self.repeat_interval)

                  # Update GUI status
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("success"))
                  print("[BlindTx] Done.")

          def work(self, input_items, output_items):
              """Not used for Message Blocks"""
              return 0
    dest_address: '2'
    preamble_len: '5000'
    repeat_count: '10'
    repeat_interval_seconds: '0.5'
    src_address: '1'
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 3,0,1,2
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    size: '20'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 1.5e6
    center_freq: freq1_0
    dev_args: bladerf=0
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq1
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freq1
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 1.5e6
    center_freq: freq1_0
    dev_args: bladerf=0
    gain: '30.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ack
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ack
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', epy_block_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', epy_block_2, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', epy_block_5_1, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3_1, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_6, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', epy_block_4_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_throttle2_0_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0_0, '0', zeromq_pub_sink_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', epy_block_5_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_append_0, out, epy_block_0_1, in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_check_0, ok, virtual_sink_2, '0']
- [digital_crc_check_0_0, fail, blocks_message_debug_0_1, log]
- [digital_crc_check_0_0, ok, blocks_message_debug_1, log]
- [digital_crc_check_0_0, ok, epy_block_1_0, pdus_in]
- [digital_crc_check_0_0, ok, epy_block_3_2, pdus_in]
- [digital_crc_check_0_0, ok, epy_block_3_3, pdus_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0, '0', virtual_sink_0_0, '0']
- [digital_map_bb_0, '0', virtual_sink_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, epy_block_10, in]
- [digital_protocol_formatter_async_0, header, epy_block_4, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, blocks_message_debug_0, log]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, pdus_out, digital_crc_append_0, in]
- [epy_block_0_1, out, digital_protocol_formatter_async_0, in]
- [epy_block_0_1_0, dest_addr, epy_block_0_1, addr_in]
- [epy_block_0_1_0, out, epy_block_2_0_0, in]
- [epy_block_1, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [epy_block_10, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_11, pdus, digital_crc_append_0, in]
- [epy_block_11, status_out, epy_block_8, status_in]
- [epy_block_12, pdus, digital_crc_append_0, in]
- [epy_block_12, status_out, epy_block_14, feedback]
- [epy_block_12, status_out, epy_block_8, status_in]
- [epy_block_13, ack_out, digital_crc_append_0_0, in]
- [epy_block_14, dest_addr, epy_block_12, dest_addr_in]
- [epy_block_14, out, epy_block_12, msg_in]
- [epy_block_1_0, pdus_out, epy_block_3_2, pdus_in]
- [epy_block_2, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [epy_block_2_0_0, feedback, epy_block_0_1_0, feedback]
- [epy_block_2_0_0, feedback, epy_block_8, status_in]
- [epy_block_2_0_0, out, digital_crc_append_0, in]
- [epy_block_3, '0', digital_constellation_modulator_0, '0']
- [epy_block_3, '0', epy_block_5, '0']
- [epy_block_3_0, '0', digital_constellation_modulator_0, '0']
- [epy_block_3_0, '0', epy_block_5, '0']
- [epy_block_3_1, '0', digital_constellation_modulator_0, '0']
- [epy_block_3_1, '0', epy_block_5, '0']
- [epy_block_3_2, ack_packet_out, digital_crc_append_0_0, in]
- [epy_block_3_2, pdus_out, epy_block_0_0, pdus]
- [epy_block_3_3, ack_packet_out, blocks_message_debug_2, log]
- [epy_block_3_3, ack_packet_out, blocks_message_debug_4, log]
- [epy_block_3_3, ack_packet_out, epy_block_13, ack_in]
- [epy_block_3_3, pdus_out, epy_block_14, in]
- [epy_block_3_3, pdus_out, epy_block_7, pdus_in]
- [epy_block_4, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_4_0, '0', digital_constellation_modulator_0_0, '0']
- [epy_block_5_1, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [epy_block_6, '0', digital_constellation_modulator_0, '0']
- [epy_block_6, '0', epy_block_5, '0']
- [epy_block_8, msg_out, epy_block_11, msg_in]
- [epy_block_8, msg_out, epy_block_12, msg_in]
- [epy_block_8, msg_out, epy_block_2_0_0, in]
- [epy_block_8, msg_out, epy_block_9, msg_in]
- [epy_block_8, msg_out, epy_block_9_0, msg_in]
- [epy_block_9, pdus, digital_crc_append_0, in]
- [epy_block_9, status_out, epy_block_8, status_in]
- [epy_block_9_0, pdus, digital_crc_append_0, in]
- [epy_block_9_0, status_out, epy_block_8, status_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_2, log]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, blocks_message_debug_2, log]
- [pdu_tagged_stream_to_pdu_1, pdus, blocks_message_debug_3, log]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_2, '0', epy_block_0_1_0, in]
- [virtual_source_2, '0', epy_block_11, ack_bits]
- [virtual_source_2, '0', epy_block_12, ack_in]
- [virtual_source_2, '0', epy_block_2_0_0, ack_in]
- [virtual_source_2, '0', epy_block_9, ack_bits]
- [zeromq_sub_source_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
