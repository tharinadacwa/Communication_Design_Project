options:
  parameters:
    author: User
    generate_options: qt_gui
    id: qpskk1111
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '"010101010111000100"'
    bps: '2'
    threshold: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len1"'
    packet_len: '64'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, file_path="C:/Users/Subodha/Desktop/3rd Semester/CDP\ACK/output.txt", append=False):
              gr.basic_block.__init__(
                  self,
                  name="pdu_file_writer",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.append = append  # If True, append to file; else overwrite

              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_pdu)

              # If overwrite mode, clear the file at the start

              open(self.file_path, "wb").close()

          def handle_pdu(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if pmt.is_u8vector(data):
                  byte_data = bytes(pmt.u8vector_elements(data))

                  # Determine file mode: append ("ab") or write ("wb")
                  mode = "ab" if self.append else "ab"  # still append for multiple PDUs in same run

                  with open(self.file_path, mode) as f:
                      f.write(byte_data)
    append: 'True'
    file_path: r"C:\Users\Subodha\Desktop\3rd Semester\CDP\ACK\output.txt"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, file_path=""):
              gr.basic_block.__init__(
                  self,
                  name="File to PDU",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.message_port_register_out(pmt.intern("pdus"))

          def start(self):
              try:
                  with open(self.file_path, 'rb') as f:
                      data = f.read()

                  # Create PDU: (empty metadata, payload)
                  payload = pmt.init_u8vector(len(data), bytearray(data))
                  meta = pmt.make_dict()
                  pdu = pmt.cons(meta, payload)

                  # Send PDU once at start
                  self.message_port_pub(pmt.intern("pdus"), pdu)
              except Exception as e:
                  print("[file_to_pdu_once] Error reading file:", str(e))

              return super().start()
    file_path: |
      r"C:\Users\User\my-project\acknetapp\Chats\Sent\message.txt"
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import threading
      import time
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, file_path="", interval=2.0, max_packet_size=32):
              gr.basic_block.__init__(
                  self,
                  name="File to PDU (chunked, ack-based retransmit)",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.interval = float(interval)
              self.max_packet_size = int(max_packet_size)

              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_in(pmt.intern("feedback"))
              self.set_msg_handler(pmt.intern("feedback"), self.handle_feedback)

              self._stop_event = threading.Event()
              self._ack_event = threading.Event()
              self._ack_lock = threading.Lock()
              self._expected_ack = None

              self._thread = threading.Thread(target=self._send_loop)
              self._thread.daemon = True

          def start(self):
              self._stop_event.clear()
              self._thread.start()
              return super().start()

          def stop(self):
              self._stop_event.set()
              self._ack_event.set()  # Unblock wait if active
              self._thread.join()
              return super().stop()

          def handle_feedback(self, msg):
              """Receives ACK/NACK in form of PMT tuples: ("ack", packet_num)"""
              try:
                  if pmt.is_pair(msg):
                      py_msg = pmt.to_python(msg)
                      if isinstance(py_msg, tuple) and len(py_msg) == 2:
                          cmd, pkt_num = py_msg
                          pkt_num = int(pkt_num)  # Ensure int type
                          with self._ack_lock:
                              if cmd == "ack" and pkt_num == self._expected_ack:
                                  print(f"[FileToPDU] Received ACK for packet #{pkt_num:02X}")
                                  self._ack_event.set()
                              elif cmd == "nack" and pkt_num == self._expected_ack:
                                  print(f"[FileToPDU] Received NACK for packet #{pkt_num:02X}, retransmitting.")
                                  self._ack_event.clear()
              except Exception as e:
                  print(f"[FileToPDU] Error handling feedback: {str(e)}")

          def _send_loop(self):
              try:
                  with open(self.file_path, 'rb') as f:
                      data = f.read()
              except Exception as e:
                  print(f"[FileToPDU] Error reading file: {str(e)}")
                  return

              # Split data into chunks (reserve 1 byte for packet number)
              chunks = [
                  data[i:i + self.max_packet_size - 1]
                  for i in range(0, len(data), self.max_packet_size - 1)
              ]

              packet_number = 1

              for chunk in chunks:
                  if self._stop_event.is_set():
                      break

                  # Prepend packet number (1 byte)
                  full_packet = bytes([packet_number]) + chunk
                  payload = pmt.init_u8vector(len(full_packet), bytearray(full_packet))
                  meta = pmt.make_dict()
                  pdu = pmt.cons(meta, payload)

                  with self._ack_lock:
                      self._expected_ack = packet_number
                      self._ack_event.clear()

                  retry_count = 0
                  max_retries = 100

                  while not self._stop_event.is_set() and retry_count < max_retries:
                      self.message_port_pub(pmt.intern("pdus"), pdu)
                      print(f"[FileToPDU] Sent packet #{packet_number:02X}, attempt {retry_count + 1}")

                      # Wait for ACK with timeout
                      ack_received = self._ack_event.wait(timeout=self.interval)

                      if ack_received:
                          break  # ACK received, proceed
                      else:
                          print(f"[FileToPDU] Timeout waiting for ACK for packet #{packet_number:02X}, retrying...")
                          retry_count += 1

                  if retry_count == max_retries:
                      print(f"[FileToPDU] Failed to receive ACK after {max_retries} attempts, moving to next packet.")

                  # Move to next packet number (wrap after 0xFF)
                  packet_number = (packet_number + 1) & 0xFF
                  if packet_number == 0x00:
                      packet_number = 0x01
    file_path: |
      r"C:\Users\Subodha\Desktop\3rd Semester\CDP\ACK\input.txt"
    interval: '0.1'
    max_packet_size: '32'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_deduplicator",
                  in_sig=[],
                  out_sig=[]
              )

              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_out(pmt.intern("feedback"))

              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_pdu)
              self.seen_packets = set()

          def handle_pdu(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  print("[Deduplicator] Invalid data type.")
                  return

              byte_data = bytearray(pmt.u8vector_elements(data))

              if len(byte_data) == 0:
                  print("[Deduplicator] Empty PDU received.")
                  nack = pmt.to_pmt(("nack", 0x00))  # or unknown packet
                  self.message_port_pub(pmt.intern("feedback"), nack)
                  return

              packet_num = byte_data[0]

              if packet_num in self.seen_packets:
                  # Duplicate packet
                  print(f"[Deduplicator] Duplicate packet #{packet_num:02X} discarded.")
                  nack = pmt.to_pmt(("nack", packet_num))
                  self.message_port_pub(pmt.intern("feedback"), nack)
                  return

              # New packet
              self.seen_packets.add(packet_num)

              # Send ACK
              ack = pmt.cons(pmt.intern("ack"), pmt.from_long(packet_num))
              #ack = pmt.to_pmt(("ack", packet_num))
              print(pmt.is_pair(ack))  
              self.message_port_pub(pmt.intern("feedback"), ack)

              # Strip first byte and forward payload
              stripped_data = byte_data[1:]
              payload = pmt.init_u8vector(len(stripped_data), stripped_data)
              pdu = pmt.cons(pmt.make_dict(), payload)

              self.message_port_pub(pmt.intern("pdus_out"), pdu)
              print(f"[Deduplicator] Passed packet #{packet_num:02X} and sent ACK.")
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len1
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    size: '20'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0_1, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_check_0, ok, epy_block_3, pdus_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', virtual_sink_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_1, pdus, digital_crc_append_0, in]
- [epy_block_2, pdus, digital_crc_append_0, in]
- [epy_block_3, feedback, blocks_message_debug_1, log]
- [epy_block_3, feedback, epy_block_2, feedback]
- [epy_block_3, pdus_out, epy_block_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, log]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_0_1, pdus, blocks_message_debug_0_0, log]
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
