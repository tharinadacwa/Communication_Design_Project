options:
  parameters:
    author: User
    generate_options: qt_gui
    id: qpskk1111
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: equalizer
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '15'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: freq1_0
  id: variable
  parameters:
    value: 0.9e9
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq2_0
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.6'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: phase_bw_0
  id: variable
  parameters:
    value: '0.0628'
  states: {state: disabled}
- name: phase_bw_0
  id: variable_qtgui_range
  parameters:
    start: '10.8e-3'
    step: '0.5e-3'
    stop: '100.8e-3'
    value: '50e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: thresh_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: thresh_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_adaptive_algorithm_0_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '"010101010111000100"'
    bps: '2'
    threshold: '2'
  states: {}
- name: variable_header_format_default_0_0
  id: variable_header_format_default
  parameters:
    access_code: '"010101010111000100"'
    bps: '2'
    threshold: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: equalizer
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '32.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os, pmt
      from gnuradio import gr

      try:
          # PyCryptodome
          from Crypto.Cipher import AES
      except ImportError:
          AES = None

      class aes_gcm_encrypt_pdu(gr.basic_block):
          def __init__(self, key_hex="00112233445566778899aabbccddeeff"):
              gr.basic_block.__init__(self,
                  name="AES-GCM Encrypt (PDU)",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.set_msg_handler(pmt.intern("pdus_in"), self._handle)
              self.message_port_register_out(pmt.intern("pdus_out"))

              self.key = bytes.fromhex(key_hex)
              if AES is None:
                  print("[AES-GCM Encrypt] ERROR: PyCryptodome not found. Install with: pip install pycryptodome")

          def _handle(self, msg):
              if AES is None:
                  return
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  print("[AES-GCM Encrypt] Non-u8vector payload")
                  return
              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) == 0:
                  return

              # Keep first byte (seq) in clear; encrypt the rest
              seq = data[0:1]
              plain = bytes(data[1:])

              # 12-byte IV (nonce)
              iv = os.urandom(12)
              cipher = AES.new(self.key, AES.MODE_GCM, nonce=iv)

              # Optionally bind AAD (e.g., sequence byte) so tag covers it
              cipher.update(seq)

              ciphertext, tag = cipher.encrypt_and_digest(plain)

              # Output payload = [seq][IV(12)][ciphertext][tag(16)]
              out = seq + iv + ciphertext + tag
              out_u8 = pmt.init_u8vector(len(out), list(out))
              out_pdu = pmt.cons(meta, out_u8)
              self.message_port_pub(pmt.intern("pdus_out"), out_pdu)
    key_hex: '''00112233445566778899aabbccddeeff'''
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, file_path="/home/manethb2003/Downloads/output.txt", append=False):
              gr.basic_block.__init__(
                  self,
                  name="pdu_file_writer",
                  in_sig=[],
                  out_sig=[]
              )

              self.file_path = file_path
              self.append = append  # If True, append to file; else overwrite

              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_pdu)

              # If overwrite mode, clear the file at the start

              open(self.file_path, "wb").close()

          def handle_pdu(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if pmt.is_u8vector(data):
                  byte_data = bytes(pmt.u8vector_elements(data))

                  # Determine file mode: append ("ab") or write ("wb")
                  mode = "ab" if self.append else "ab"  # still append for multiple PDUs in same run

                  with open(self.file_path, mode) as f:
                      f.write(byte_data)
    append: 'True'
    file_path: r"/home/manethb2003/Downloads/output.txt"
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    BitLimiter (fixed byte count):\n    - Wait for tag with name tag_key\n    - When seen, forward exactly packet_bytes bytes\n    \"\"\"\n\n    def __init__(self, tag_key=\"packet_start\", packet_bytes=32):\n        gr.sync_block.__init__(\n            self,\n            name=\"BitLimiterBytes\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8]\n        )\n\n        self.tag_key = pmt.intern(tag_key)\n        self.packet_bytes = int(packet_bytes)\n\n        # State\n        self.active = False\n        self.bytes_remaining = 0\n\n    def work(self, input_items, output_items):\n\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_in = len(inp)\n        out_index = 0\n\n        # ---- Detect tag ----\n        tags = self.get_tags_in_window(0, 0, n_in)\n\n        for t in tags:\n            if t.key == self.tag_key:\n                # Start forwarding packet_bytes bytes\n                self.bytes_remaining = self.packet_bytes\n                self.active = True\n\n        # ---- Forward data ----\n        for i in range(n_in):\n\n            if self.active and self.bytes_remaining > 0:\n                out[out_index] = inp[i]\n                out_index += 1\n                self.bytes_remaining -= 1\n\n                if self.bytes_remaining == 0:\n                    self.active = False\n\n        return out_index\n\n"
    packet_bytes: '8'
    tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):

          def __init__(self, num_bytes=4):
              gr.basic_block.__init__(
                  self,
                  name="PDU Prepend Random Bytes",
                  in_sig=None,
                  out_sig=None
              )

              self.num_bytes = int(num_bytes)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_msg)


          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = pmt.cdr(msg)

              payload = bytes(pmt.u8vector_elements(vec))

              # random bytes
              prepend = np.random.randint(0, 256, self.num_bytes, dtype=np.uint8).tolist()

              # convert payload to list of ints
              payload_list = list(payload)

              # final output list
              out_list = prepend + payload_list

              # convert back to PDU
              out_vec = pmt.init_u8vector(len(out_list), out_list)

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(meta, out_vec)
              )
    num_bytes: '10000'
  states: {state: disabled}
- name: epy_block_11
  id: epy_block
  parameters:
    _source_code: "import pmt\nimport os\nimport threading\nimport time\nfrom gnuradio import gr\n\nclass TextToPDU_ARQ(gr.basic_block):\n    def __init__(self, max_packet_size=32, src_address=1, dest_address=2):\n        gr.basic_block.__init__(\n            self,\n            name=\"Text to PDU (ARQ Logic + 10000 Bytes Prepend)\",\n            in_sig=[],\n            out_sig=[]\n        )\n        \n        # --- CONFIGURATION ---\n        self.interval = 0.1\n        self.max_packet_size = int(max_packet_size)\n        self.src_address = int(src_address) & 0xFF\n        self.dest_address = int(dest_address) & 0xFF\n        self._sync_bits = 10000\n        # -------------------\n\n        # Hardcoded 10000 bytes (example: repeating pattern 0x12..0xF0)\n        base = [0x12, 0x34, 0x56, 0x78, 0x9A, 0xBC, 0xDE, 0xF0]\n        self.prepend_bytes = (base * 10000)[:10000]\n        print(\"prepend ready\")\n\n        # Message ports\n        self.message_port_register_out(pmt.intern(\"pdus\"))\n        self.message_port_register_in(pmt.intern(\"ack_bits\"))\n        self.set_msg_handler(pmt.intern(\"ack_bits\"), self.handle_ack_bits)\n\n        self.message_port_register_in(pmt.intern(\"msg_in\"))\n        self.set_msg_handler(pmt.intern(\"msg_in\"), self.handle_msg_input)\n        self.message_port_register_out(pmt.intern(\"status_out\"))\n\n        # Threading / state\n        self._stop_event = threading.Event()\n        self._ack_event = threading.Event()\n        self._ack_lock = threading.Lock()\n        self._expected_ack = None\n        self._tx_lock = threading.Lock()\n\n    def stop(self):\n        self._stop_event.set()\n        self._ack_event.set()\n        return super().stop()\n\n    def handle_msg_input(self, msg):\n        text_data = pmt.symbol_to_string(msg)\n        if self._tx_lock.locked():\n            return\n        t = threading.Thread(target=self._process_transmission, args=(text_data,))\n        t.daemon = True\n        t.start()\n    \n        # -------------------------------------------------\n    # Sync Burst Sender (PURE RANDOM BYTES)\n    # -------------------------------------------------\n    def _send_sync_burst(self):\n        if self._sync_bits <= 0:\n            return\n\n        # Pure random bytes, no header\n        sync_data = os.urandom(self._sync_bits)\n\n        vec = pmt.init_u8vector(len(sync_data), list(sync_data))\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        print(f\"[pdu_text_gui] SYNC BURST sent ({len(sync_data)} bytes)\")\n        self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n    def _process_transmission(self, text_data):\n        with self._tx_lock:\n            self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"pending\"))\n            \n            data = text_data.encode('utf-8')\n            chunk_size = self.max_packet_size - 3\n            chunks = [data[i:i + chunk_size] for i in range(0, len(data), chunk_size)]\n\n            packet_number = 1\n            success = True\n\n            # --- SEND NORMAL PACKETS ---\n            for chunk in chunks:\n                if self._stop_event.is_set():\n                    success = False\n                    break\n\n                # prepend 10000 bytes\n                full_packet = bytes([self.src_address, self.dest_address, packet_number]) + chunk\n                payload = pmt.init_u8vector(len(full_packet), list(full_packet))\n                #pdu = pmt.cons(pmt.make_dict(), payload)\n                \n                self._send_sync_burst()\n                pdu = pmt.cons(pmt.PMT_NIL, payload)\n\n                with self._ack_lock:\n                    self._expected_ack = packet_number\n                    self._ack_event.clear()\n\n                retry_count = 0\n                max_retries = 200\n                chunk_sent_successfully = False\n\n                while not self._stop_event.is_set() and retry_count < max_retries:\n                    self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n                    ack_received = self._ack_event.wait(timeout=self.interval)\n                    if ack_received:\n                        chunk_sent_successfully = True\n                        break\n                    else:\n                        retry_count += 1\n\n                if not chunk_sent_successfully:\n                    print(f\"[ARQ] Failed to send packet #{packet_number:02X}\")\n                    success = False\n                    break\n\n                packet_number = (packet_number + 1) & 0xFF\n                if packet_number == 0x00:\n                    packet_number = 0x01\n\n            # --- SEND TERMINATION PACKET ---\n            if success and not self._stop_event.is_set():\n                term_packet_number = packet_number\n                term_payload_len = (self.max_packet_size + 1) - 3\n                term_payload = bytes([0xFF] * term_payload_len)\n\n                full_packet = bytes([self.src_address, self.dest_address, term_packet_number]) + term_payload\n                payload = pmt.init_u8vector(len(full_packet), list(full_packet))\n                #pdu = pmt.cons(pmt.make_dict(), payload)\n                \n                self._send_sync_burst()\n                pdu = pmt.cons(pmt.PMT_NIL, payload)\n\n                with self._ack_lock:\n                    self._expected_ack = term_packet_number\n                    self._ack_event.clear()\n\n\n                retry_count = 0\n                max_retries = 200\n                term_success = False\n\n                while not self._stop_event.is_set() and retry_count < max_retries:\n                    self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n                    ack_received = self._ack_event.wait(timeout=self.interval)\n                    if ack_received:\n                        term_success = True\n                        break\n                    else:\n                        print(f\"[ARQ] Timeout waiting for TERMINATION ACK #{term_packet_number:02X}\")\n                        retry_count += 1\n\n                if not term_success:\n                    print(f\"[ARQ] Failed to send TERMINATION packet #{term_packet_number:02X}\")\n                    success = False\n\n            # Update GUI\n            if success:\n                self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"success\"))\n            else:\n                self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"fail\"))\n\n    def handle_ack_bits(self, msg):\n        try:\n            data = pmt.cdr(msg)\n            if not pmt.is_u8vector(data):\n                return\n\n            byte_data = bytearray(pmt.u8vector_elements(data))\n            if len(byte_data) < 4:\n                return\n            \n            if byte_data[0] != 0xAA:\n                return\n\n            ack_src_addr = byte_data[1]\n            ack_dest_addr = byte_data[2]\n            ack_packet_num = byte_data[3]\n\n            if ack_dest_addr != self.src_address:\n                return\n            if ack_src_addr != self.dest_address:\n                return\n\n            with self._ack_lock:\n                if ack_packet_num == self._expected_ack:\n                    self._ack_event.set()\n                    \n        except Exception as e:\n            print(f\"[ARQ] Error handling ACK: {str(e)}\")\n\n"
    dest_address: '2'
    max_packet_size: '32'
    src_address: '1'
  states: {}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport threading\nimport pmt\nimport time\nimport os\nfrom gnuradio import gr\n\nclass TextToPDU_ARQ(gr.basic_block):\n\n    def __init__(self, pkt_size=32, src_addr=1, dst_addr=2,\n                 sync_burst_bytes=10000, timeout=0.1, retry_limit=200):\n\n        gr.basic_block.__init__(\n            self,\n            name=\"Text to PDU ARQ (with Prepend Burst)\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # ---------------- PARAMETERS ----------------\n        self._pkt_size = int(pkt_size)\n        self._src = int(src_addr) & 0xFF\n        self._dst = int(dst_addr) & 0xFF\n        self._sync_len = int(sync_burst_bytes)\n        self._timeout = float(timeout)\n        self._retry_limit = int(retry_limit)\n        # --------------------------------------------\n\n        # Ports\n        self.message_port_register_in(pmt.intern(\"msg_in\"))\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n        self.message_port_register_out(pmt.intern(\"pdus\"))\n        self.message_port_register_out(pmt.intern(\"status_out\"))\n\n        self.set_msg_handler(pmt.intern(\"msg_in\"), self._process_text)\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self._process_ack)\n\n        # State\n        self._tx_thread = None\n        self._stop = threading.Event()\n        self._ack_event = threading.Event()\n        self._ack_lock = threading.Lock()\n        self._expected_ack = None\n\n    # ================================================================\n    #  SEND SYNC BURST  (PURE RANDOM BYTES AS A SEPARATE PDU)\n    # ================================================================\n    def _send_prepend_burst(self):\n        if self._sync_len <= 0:\n            return\n\n        raw = os.urandom(self._sync_len)\n        vec = pmt.init_u8vector(len(raw), list(raw))\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        print(f\"[ARQ] PREPEND BURST ({len(raw)} bytes)\")\n        self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n\n    # ================================================================\n    #  HANDLE INPUT TEXT\n    # ================================================================\n    def _process_text(self, msg):\n        try:\n            text = pmt.symbol_to_string(msg)\n        except:\n            print(\"[ARQ] Invalid PMT text\")\n            return\n\n        if self._tx_thread is None or not self._tx_thread.is_alive():\n            self._stop.clear()\n            self._tx_thread = threading.Thread(target=self._run, args=(text,))\n            self._tx_thread.daemon = True\n            self._tx_thread.start()\n\n    # ================================================================\n    #  MAIN TRANSMISSION (STOP-AND-WAIT)\n    # ================================================================\n    def _run(self, text):\n        data = text.encode(\"utf-8\")\n        chunk_size = self._pkt_size - 3\n        chunks = [data[i:i+chunk_size] for i in range(0, len(data), chunk_size)]\n\n        pkt_num = 1\n        success = True\n\n        # ---------------- NORMAL PACKETS ----------------\n        for chunk in chunks:\n            if not self._send_single_packet(chunk, pkt_num):\n                success = False\n                break\n\n            pkt_num = (pkt_num + 1) & 0xFF\n            if pkt_num == 0:\n                pkt_num = 1\n\n        # ---------------- TERMINATION PACKET ----------------\n        if success and not self._stop.is_set():\n            term_size = (self._pkt_size + 1) - 3\n            term_payload = bytes([0xFF] * term_size)\n            if not self._send_single_packet(term_payload, pkt_num, termination=True):\n                success = False\n\n        # ---------------- UPDATE GUI ----------------\n        if success:\n            self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"success\"))\n        else:\n            self.message_port_pub(pmt.intern(\"status_out\"), pmt.intern(\"fail\"))\n\n    # ================================================================\n    #  SEND ONE PACKET WITH ARQ\n    # ================================================================\n    def _send_single_packet(self, chunk, pkt_num, termination=False):\n\n        header = bytes([self._src, self._dst, pkt_num])\n        full_packet = header + chunk\n\n        vec = pmt.init_u8vector(len(full_packet), list(full_packet))\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        with self._ack_lock:\n            self._expected_ack = pkt_num\n            self._ack_event.clear()\n\n        retries = 0\n\n        while retries < self._retry_limit and not self._stop.is_set():\n\n            # PREPEND BURST BEFORE EVERY PDU\n            self._send_prepend_burst()\n\n            # SEND PACKET\n            self.message_port_pub(pmt.intern(\"pdus\"), pdu)\n            print(f\"[ARQ] Sent packet #{pkt_num:02X}\")\n\n            # WAIT FOR ACK\n            if self._ack_event.wait(timeout=self._timeout):\n                print(f\"[ARQ] ACK for #{pkt_num:02X}\")\n                return True\n\n            retries += 1\n            print(f\"[ARQ] Timeout → retry {retries}\")\n\n        print(f\"[ARQ] FAILED packet #{pkt_num:02X}\")\n        return False\n\n    # ================================================================\n    #  ACK HANDLER\n    # ================================================================\n    def _process_ack(self, msg):\n        try:\n            data = pmt.cdr(msg)\n            if not pmt.is_u8vector(data):\n                return\n\n            arr = bytearray(pmt.u8vector_elements(data))\n            if len(arr) < 4:\n                return\n            if arr[0] != 0xAA:\n                return\n\n            src = arr[1]\n            dst = arr[2]\n            ack_id = arr[3]\n\n            if src != self._dst or dst != self._src:\n                return\n\n            with self._ack_lock:\n                if ack_id == self._expected_ack:\n                    self._ack_event.set()\n\n        except Exception as e:\n            print(f\"[ARQ] ACK error: {e}\")\n\n"
    dst_addr: '2'
    pkt_size: '32'
    retry_limit: '100'
    src_addr: '1'
    sync_burst_bytes: '10000'
    timeout: '0.1'
  states: {state: disabled}
- name: epy_block_13
  id: epy_block
  parameters:
    _source_code: "import os\nimport pmt\nfrom gnuradio import gr\n\nclass ack_sync_prepender(gr.basic_block):\n    \"\"\"\n    Inserts a sync burst BEFORE every ACK PDU.\n    The sync burst function sends the burst itself.\n    \"\"\"\n\n    def __init__(self, sync_len_bytes=2000):\n        gr.basic_block.__init__(\n            self,\n            name=\"ack_sync_prepender\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.sync_len = int(sync_len_bytes)\n\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n        self.message_port_register_out(pmt.intern(\"ack_out\"))\n\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self.handle_ack)\n\n\n    # --------------------------------------------------------\n    # This function CREATES + PUBLISHES the sync burst itself\n    # --------------------------------------------------------\n    def send_sync_burst(self):\n        sync_data = os.urandom(self.sync_len)\n\n        vec = pmt.init_u8vector(self.sync_len, list(sync_data))\n        burst_pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        # <---- the burst is SENT here ---->\n        self.message_port_pub(pmt.intern(\"ack_out\"), burst_pdu)\n\n        print(f\"[ACK SYNC] Sent burst ({self.sync_len} bytes)\")\n\n\n    # --------------------------------------------------------\n    # ACK handler\n    # --------------------------------------------------------\n    def handle_ack(self, msg):\n        \"\"\"\n        msg is the original ACK PDU.\n\n        This block outputs:\n\n            [SYNC BURST]\n            [ACK PDU]\n        \"\"\"\n        # 1) send the sync burst\n        self.send_sync_burst()\n\n        # 2) forward ACK\n        self.message_port_pub(pmt.intern(\"ack_out\"), msg)\n\n        print(f\"[ACK SYNC] Forwarded ACK\")\n\n"
    sync_len_bytes: '10000'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      try:
          from Crypto.Cipher import AES
      except ImportError:
          AES = None

      class aes_gcm_decrypt_pdu(gr.basic_block):
          def __init__(self, key_hex="00112233445566778899aabbccddeeff"):
              gr.basic_block.__init__(self,
                  name="AES-GCM Decrypt (PDU)",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.set_msg_handler(pmt.intern("pdus_in"), self._handle)
              self.message_port_register_out(pmt.intern("pdus_out"))

              self.key = bytes.fromhex(key_hex)
              if AES is None:
                  print("[AES-GCM Decrypt] ERROR: PyCryptodome not found. Install with: pip install pycryptodome")

          def _handle(self, msg):
              if AES is None:
                  return
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  print("[AES-GCM Decrypt] Non-u8vector payload")
                  return
              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) < 1 + 12 + 16:
                  print("[AES-GCM Decrypt] Frame too short")
                  return

              seq = bytes([data[0]])
              iv  = bytes(data[1:1+12])
              tag = bytes(data[-16:])
              ciphertext = bytes(data[1+12:-16])

              try:
                  cipher = AES.new(self.key, AES.MODE_GCM, nonce=iv)
                  cipher.update(seq)  # must match encrypt side
                  plain = cipher.decrypt_and_verify(ciphertext, tag)
              except Exception as e:
                  print(f"[AES-GCM Decrypt] Auth failed: {e}")
                  return  # drop corrupted/forged frame

              # Rebuild original PDU payload: [seq][plaintext]
              out = seq + plain
              out_u8 = pmt.init_u8vector(len(out), list(out))
              out_pdu = pmt.cons(meta, out_u8)
              self.message_port_pub(pmt.intern("pdus_out"), out_pdu)
    key_hex: '''00112233445566778899aabbccddeeff'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          BitLimiter (fixed byte count):
          - Wait for tag with name tag_key
          - When seen, forward exactly packet_bytes bytes
          """

          def __init__(self, tag_key="packet_start", packet_bytes=32):
              gr.sync_block.__init__(
                  self,
                  name="BitLimiterBytes",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_key)
              self.packet_bytes = int(packet_bytes)

              # State
              self.active = False
              self.bytes_remaining = 0

          def work(self, input_items, output_items):

              inp = input_items[0]
              out = output_items[0]

              n_in = len(inp)
              out_index = 0

              # ---- Detect tag ----
              tags = self.get_tags_in_window(0, 0, n_in)

              for t in tags:
                  if t.key == self.tag_key:
                      # Start forwarding packet_bytes bytes
                      self.bytes_remaining = self.packet_bytes
                      self.active = True

              # ---- Forward data ----
              for i in range(n_in):

                  if self.active and self.bytes_remaining > 0:
                      out[out_index] = inp[i]
                      out_index += 1
                      self.bytes_remaining -= 1

                      if self.bytes_remaining == 0:
                          self.active = False

              return out_index
    packet_bytes: '53'
    tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport threading\nimport pmt\nimport time\nimport os\nfrom gnuradio import gr\n\nclass pdu_text_gui(gr.basic_block):\n    \"\"\"\n    Custom block: QT GUI Message Entry -> PDU sender with Go-Back-N ARQ.\n    NOW SUPPORTS:\n    - sync_bits : number of random bytes transmitted before each retransmission.\n    - Sync burst has NO headers, NO packetization. It is PURE RANDOM BYTE STREAM.\n    \"\"\"\n\n    def __init__(self, wait_time=2.0, pkt_size=32, address=0x01,\n                 retry_limit=100, window_size=4, sync_bits=1000):\n\n        gr.basic_block.__init__(\n            self,\n            name=\"GUI Text to PDU with Go-Back-N ARQ + Sync Burst\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # Parameters\n        self._timeout = float(wait_time)\n        self._pkt_size = int(pkt_size)\n        self._address = int(address) & 0xFF\n        self._retry_limit = int(retry_limit)\n        self._window_size = int(window_size)\n        self._sync_bits = int(sync_bits)   # NEW PARAMETER\n\n        # Seq/ACK control\n        self._seq_id = 1\n        self._last_ack_seq = 0\n        self._has_acks = False\n\n        # Register message ports\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_out(pmt.intern(\"feedback\"))\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._process_text)\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self._process_ack)\n\n        # Thread control\n        self._thread = None\n        self._stop_event = threading.Event()\n        self._lock = threading.Lock()\n\n        # Data buffers\n        self._text_data = b\"\"\n        self._packets = []\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n        self._end_seq_id = 0\n\n    # -------------------------------------------------\n    # Sync Burst Sender (PURE RANDOM BYTES)\n    # -------------------------------------------------\n    def _send_sync_burst(self):\n        if self._sync_bits <= 0:\n            return\n\n        # Pure random bytes, no header\n        sync_data = os.urandom(self._sync_bits)\n\n        vec = pmt.init_u8vector(len(sync_data), list(sync_data))\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n        print(f\"[pdu_text_gui] SYNC BURST sent ({len(sync_data)} bytes)\")\n        self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n    # -------------------------------------------------\n    # Handle input text\n    # -------------------------------------------------\n    def _process_text(self, msg):\n        try:\n            if pmt.is_symbol(msg):\n                text_str = pmt.symbol_to_string(msg)\n            elif pmt.is_string(msg):\n                text_str = pmt.string_to_string(msg)\n            else:\n                print(\"[pdu_text_gui] Invalid PMT format\")\n                return\n\n            self._text_data = text_str.encode(\"utf-8\")\n\n            if self._thread is None or not self._thread.is_alive():\n                self._stop_event.clear()\n                self._thread = threading.Thread(target=self._run)\n                self._thread.daemon = True\n                self._thread.start()\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] Error processing text: {e}\")\n\n    # -------------------------------------------------\n    # Main ARQ loop\n    # -------------------------------------------------\n    def _run(self):\n        raw = self._text_data\n        step = self._pkt_size - 2\n        blocks = [raw[i:i+step] for i in range(0, len(raw), step)]\n\n        # Choose starting seq\n        if self._has_acks:\n            self._seq_id = (self._last_ack_seq + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n        else:\n            self._seq_id = 1\n\n        print(f\"[pdu_text_gui] Starting TX at seq=0x{self._seq_id:02X}\")\n\n        # Build packets\n        self._packets = []\n        for block in blocks:\n            packet = bytes([self._address, self._seq_id]) + block\n            self._packets.append((self._seq_id, packet))\n\n            self._seq_id = (self._seq_id + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n\n        # End packet\n        end_packet = bytes([self._address, self._seq_id])\n        self._packets.append((self._seq_id, end_packet))\n        self._end_seq_id = self._seq_id\n\n        print(f\"[pdu_text_gui] END packet: seq=0x{self._seq_id:02X}\")\n\n        self._seq_id = (self._seq_id + 1) & 0xFF\n        if self._seq_id == 0:\n            self._seq_id = 1\n\n        # Reset window\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n\n        # --------------------------------------------------\n        # ARQ LOOP\n        # --------------------------------------------------\n        while self._base < len(self._packets) and not self._stop_event.is_set():\n\n            # Try sending packets in window\n            with self._lock:\n                while self._next_to_send < self._base + self._window_size and \\\n                      self._next_to_send < len(self._packets):\n\n                    seq_id, packet = self._packets[self._next_to_send]\n\n                    vec = pmt.init_u8vector(len(packet), list(packet))\n                    pdu = pmt.cons(pmt.PMT_NIL, vec)\n                    self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n                    if len(packet) > 2:\n                        print(f\"[pdu_text_gui] Sent id=0x{seq_id:02X}\")\n                    else:\n                        print(f\"[pdu_text_gui] Sent END id=0x{seq_id:02X}\")\n\n                    self._next_to_send += 1\n\n            # Wait for ACK\n            time.sleep(self._timeout)\n\n            # Timeout -> Retransmit window\n            with self._lock:\n                if self._base < self._next_to_send:\n\n                    self._attempts += 1\n                    if self._attempts >= self._retry_limit:\n                        print(\"[pdu_text_gui] Retry limit exceeded\")\n                        self.message_port_pub(pmt.intern(\"feedback\"),\n                                              pmt.intern(\"RETRY_LIMIT_EXCEEDED\"))\n                        self._stop_event.set()\n                        break\n\n                    print(\"[pdu_text_gui] TIMEOUT → Sync Burst + Retransmit window\")\n\n                    # 🔥 SEND RAW SYNC BURST FIRST\n                    self._send_sync_burst()\n\n                    # retransmit packets\n                    for i in range(self._base, self._next_to_send):\n                        seq_id, packet = self._packets[i]\n\n                        vec = pmt.init_u8vector(len(packet), list(packet))\n                        pdu = pmt.cons(pmt.PMT_NIL, vec)\n                        self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n                        if len(packet) > 2:\n                            print(f\"[pdu_text_gui] Retransmit id=0x{seq_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] Retransmit END id=0x{seq_id:02X}\")\n\n    # -------------------------------------------------\n    # ACK handler\n    # -------------------------------------------------\n    def _process_ack(self, msg):\n        try:\n            payload = pmt.cdr(msg)\n            if not pmt.is_u8vector(payload):\n                return\n\n            arr = bytearray(pmt.u8vector_elements(payload))\n            if len(arr) < 2:\n                return\n            if arr[0] != 0xAA:\n                return\n\n            ack_id = arr[1]\n\n            with self._lock:\n                for i in range(self._base, self._next_to_send):\n                    seq_id, _ = self._packets[i]\n\n                    if seq_id == ack_id:\n                        self._has_acks = True\n                        self._last_ack_seq = ack_id\n\n                        if len(self._packets[i][1]) > 2:\n                            print(f\"[pdu_text_gui] ACK for 0x{ack_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] ACK END 0x{ack_id:02X}\")\n                            self.message_port_pub(pmt.intern(\"feedback\"),\n                                                  pmt.intern(\"END_ACK_RECEIVED\"))\n\n                        self._base = i + 1\n                        self._attempts = 0\n                        break\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] ACK error: {e}\")\n\n"
    address: '50'
    pkt_size: '100'
    retry_limit: '100'
    sync_bits: 1e4
    wait_time: '0.1'
    window_size: '7'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Idle + Packet Injector
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Continuous stream block with idle bytes 0xAA.
          Injects packets from input stream (Tagged Stream Mux) whenever available.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              print(inp)

              n_out = len(out)
              in_len = len(inp)
              out_index = 0


              # ---- Append input bytes to internal buffer ----
              if in_len > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Fill output ----
              while out_index < n_out:

                  if len(self.packet_buffer) > 0:
                      # Pop from buffer
                      out[out_index] = self.packet_buffer.pop(0)
                  else:
                      # Output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Idle + Packet Injector
          Waits until the full packet (according to header length) is received before transmitting.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []
              self.expected_length = None  # Total packet length including header

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n_out = len(out)
              out_index = 0

              # ---- Append input bytes to internal buffer ----
              if len(inp) > 0:
                  self.packet_buffer.extend(inp.tolist())


              # ---- Extract expected packet length from header ----
              # Header format: XX XX XX XX 00 <length_byte> 00 <length_byte>
              if self.expected_length is None and len(self.packet_buffer) >= 6:
                  length_byte = self.packet_buffer[5]  # 0-based index for first length byte
                  self.expected_length = 8 + length_byte  # 8-byte header + payload

              # ---- Fill output ----
              while out_index < n_out:
                  if self.expected_length is not None and len(self.packet_buffer) >= self.expected_length:
                      # Full packet ready: transmit first byte
                      out[out_index] = self.packet_buffer.pop(0)
                      # If entire packet transmitted, reset expected_length
                      if len(self.packet_buffer) == 0:
                          self.expected_length = None
                  else:
                      # Not enough bytes yet: output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class IdlePacketInjectorWithLength(gr.sync_block):
          """
          Idle + Packet Injector (robust version)
          - Continuously outputs idle bytes until a full packet is buffered.
          - Transmits the entire packet (with payload-length byte first) once ready.
          - Supports back-to-back packets in the buffer.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjectorWithLength",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []
              self.expected_length = None  # total length including header
              self.payload_length = None
              self.send_length_byte = False
              self.sentcount = 0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out_index = 0

              # ---- Append new bytes to internal buffer ----
              if len(inp) > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Process output buffer ----
              while out_index < n_out:

                  # ---- Check if a full packet is available ----
                  if self.expected_length is None and len(self.packet_buffer) >= 6:
                      # Extract payload length from header
                      self.payload_length = self.packet_buffer[5]  # 0-based index
                      self.expected_length = 8 + self.payload_length
                      self.send_length_byte = True
                      self.sentcount = 0

                  # ---- If full packet is ready, transmit it ----
                  if self.expected_length is not None and len(self.packet_buffer) >= self.expected_length:
                      if self.send_length_byte:
                          # Send payload-length byte first
                          out[out_index] = self.payload_length
                          self.send_length_byte = False
                          out_index += 1
                          continue  # continue without incrementing out_index again
                      else:
                          # Send packet bytes
                          out[out_index] = self.packet_buffer.pop(0)
                          print(out[out_index])
                          self.sentcount += 1

                          # Check if packet transmission is complete
                          if self.sentcount >= self.payload_length:
                              # Remove header bytes as well
                              for _ in range(8):
                                  if self.packet_buffer:
                                      self.packet_buffer.pop(0)
                              # Reset state for next packet
                              self.expected_length = None
                              self.payload_length = None
                              self.send_length_byte = False
                              self.sentcount = 0
                  else:
                      # Not enough bytes: send idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_3_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, address=1, max_packet_size=32):  # Receiver address + packet size
              gr.basic_block.__init__(
                  self,
                  name="pdu_deduplicator",
                  in_sig=[],
                  out_sig=[]
              )

              self.address = int(address) & 0xFF
              self.max_packet_size = int(max_packet_size)

              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_out(pmt.intern("ack_packet_out"))

              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_pdu)

              self.seen_packets = set()

          def reset_sequence(self):
              """Resets deduplication state after receiving termination packet."""
              print("[Deduplicator] Resetting sequence state.")
              self.seen_packets = set()

          def handle_pdu(self, msg):

              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  print("[Deduplicator] Invalid data type.")
                  return

              byte_data = bytearray(pmt.u8vector_elements(data))

              if len(byte_data) < 3:
                  print("[Deduplicator] Packet too short.")
                  return

              src_addr = byte_data[0]
              dest_addr = byte_data[1]
              pkt_num = byte_data[2]

              # Only accept packets addressed to me
              if dest_addr != self.address:
                  return

              # ---------------------------------------------------------
              #  CHECK FOR TERMINATION PACKET
              # ---------------------------------------------------------
              expected_term_length = self.max_packet_size + 1

              if len(byte_data) == expected_term_length:
                  # termination payload = all 0xFF bytes
                  payload = byte_data[3:]
                  if all(b == 0xFF for b in payload):

                      print(f"[Deduplicator] Termination packet #{pkt_num:02X} received. Sending ACK & resetting.")

                      # Send ACK (same mechanism as normal)
                      ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])
                      ack_pdu = pmt.cons(pmt.make_dict(),
                                         pmt.init_u8vector(len(ack_packet), list(ack_packet)))

                      for _ in range(80):
                          self.message_port_pub(pmt.intern("ack_packet_out"), ack_pdu)

                      # Reset deduplication for next message
                      self.reset_sequence()

                      # DO NOT forward termination packet
                      return

              # ---------------------------------------------------------
              #  NORMAL PACKET HANDLING
              # ---------------------------------------------------------

              # Duplicate check
              if pkt_num in self.seen_packets:
                  print(f"[Deduplicator] Duplicate packet #{pkt_num:02X} discarded.")
                  return

              self.seen_packets.add(pkt_num)

              # Forward stripped payload (remove src,dest,pktnum)
              stripped_payload = byte_data[3:]
              payload = pmt.init_u8vector(len(stripped_payload), list(stripped_payload))
              pdu = pmt.cons(pmt.make_dict(), payload)
              self.message_port_pub(pmt.intern("pdus_out"), pdu)

              # Send ACK
              ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])
              ack_pdu = pmt.cons(pmt.make_dict(),
                                 pmt.init_u8vector(len(ack_packet), list(ack_packet)))

              print("[Deduplicator] Sending ACK...")
              for _ in range(80):
                  self.message_port_pub(pmt.intern("ack_packet_out"), ack_pdu)

              print(f"[Deduplicator] Accepted packet #{pkt_num:02X} from {src_addr:02X}. Sent ACK.")
    address: '2'
    max_packet_size: '32'
  states: {state: disabled}
- name: epy_block_3_3
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, address=1, max_packet_size=32):\n        gr.basic_block.__init__(\n            self,\n            name=\"pdu_deduplicator\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.address = int(address) & 0xFF\n        self.max_packet_size = int(max_packet_size)\n\n        self.message_port_register_in(pmt.intern(\"pdus_in\"))\n        self.message_port_register_out(pmt.intern(\"pdus_out\"))\n        self.message_port_register_out(pmt.intern(\"ack_packet_out\"))\n\n        self.set_msg_handler(pmt.intern(\"pdus_in\"), self.handle_pdu)\n\n        self.seen_packets = set()\n\n        # ---------------------------------------------------\n        # NEW: State for ACK forwarding\n        # ---------------------------------------------------\n        self.last_ack_forwarded = None\n        self.expected_ack_pkt = 0\n\n    def reset_sequence(self):\n        print(\"[Deduplicator] Resetting sequence state.\")\n        self.seen_packets = set()\n        self.last_ack_forwarded = None\n        self.expected_ack_pkt = 0\n\n    def handle_pdu(self, msg):\n        data = pmt.cdr(msg)\n\n        if not pmt.is_u8vector(data):\n            print(\"[Deduplicator] Invalid data type.\")\n            return\n\n        byte_data = bytearray(pmt.u8vector_elements(data))\n\n        if len(byte_data) < 3:\n            print(\"[Deduplicator] Packet too short.\")\n            return\n\n        src_addr = byte_data[0]\n        dest_addr = byte_data[1]\n        pkt_num = byte_data[2]\n\n        # ===========================================================\n        # NEW: Detect ACK packet coming *from transmitter*\n        # ===========================================================\n        if byte_data[0] == 0xAA:\n            ack_src = byte_data[1]\n            ack_dest = byte_data[2]\n            ack_num = byte_data[3]\n\n            # Check if ACK is expected\n            if ack_num == self.expected_ack_pkt:\n\n                # avoid forwarding duplicates\n                if self.last_ack_forwarded != ack_num:\n                    print(f\"[Deduplicator] Forwarding expected ACK #{ack_num:02X}.\")\n                    ack_pdu = pmt.cons(\n                        pmt.make_dict(),\n                        pmt.init_u8vector(len(byte_data), list(byte_data))\n                    )\n                    self.message_port_pub(pmt.intern(\"pdus_out\"), ack_pdu)\n                    self.last_ack_forwarded = ack_num\n\n                    # next expected ACK\n                    self.expected_ack_pkt += 1\n\n                else:\n                    print(f\"[Deduplicator] Duplicate expected ACK #{ack_num:02X} ignored.\")\n\n            else:\n                print(f\"[Deduplicator] Unexpected ACK #{ack_num:02X} discarded.\")\n\n            return\n        # ===========================================================\n\n\n        if dest_addr != self.address:\n            return\n\n        expected_term_length = self.max_packet_size + 1\n\n        # ---------------------------------------------------------\n        # TERMINATION PACKET\n        # ---------------------------------------------------------\n        if len(byte_data) == expected_term_length:\n            payload = byte_data[3:]\n            if all(b == 0xFF for b in payload):\n\n                print(f\"[Deduplicator] Termination packet #{pkt_num:02X} received.\")\n\n                # ---- Send ACK ----\n                ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])\n                ack_pdu = pmt.cons(pmt.make_dict(),\n                                   pmt.init_u8vector(len(ack_packet), list(ack_packet)))\n\n                for _ in range(80):\n                    self.message_port_pub(pmt.intern(\"ack_packet_out\"), ack_pdu)\n\n                # ---- Forward termination to next block ----\n                forward_bytes = bytes([pkt_num]) + byte_data[3:]  # pkt_num + all FFs\n                payload_pdu = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n                out = pmt.cons(pmt.make_dict(), payload_pdu)\n                self.message_port_pub(pmt.intern(\"pdus_out\"), out)\n\n                # ---- Reset dedup ----\n                self.reset_sequence()\n\n                return\n\n        # ---------------------------------------------------------\n        # NORMAL PACKET\n        # ---------------------------------------------------------\n        if pkt_num in self.seen_packets:\n            print(f\"[Deduplicator] Duplicate packet #{pkt_num:02X} discarded.\")\n            return\n\n        self.seen_packets.add(pkt_num)\n\n        forward_bytes = bytes([pkt_num]) + byte_data[3:]\n        payload = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n        out_pdu = pmt.cons(pmt.make_dict(), payload)\n        self.message_port_pub(pmt.intern(\"pdus_out\"), out_pdu)\n\n        # ACK\n        ack_packet = bytes([0xAA, self.address, src_addr, pkt_num])\n        ack_pdu = pmt.cons(pmt.make_dict(),\n                           pmt.init_u8vector(len(ack_packet), list(ack_packet)))\n\n        for _ in range(80):\n            self.message_port_pub(pmt.intern(\"ack_packet_out\"), ack_pdu)\n\n        print(f\"[Deduplicator] Accepted packet #{pkt_num:02X}.\")\n\n"
    address: '2'
    max_packet_size: '32'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    \"\"\"\n    PDU Prepend Pattern Bytes (fast & PMT-compatible)\n\n    - Prepends a fixed byte pattern to each incoming PDU.\n    - Avoids expensive per-PDU slicing by precomputing pattern chunks.\n    \"\"\"\n\n    def __init__(self, num_bytes=4):\n        gr.basic_block.__init__(\n            self,\n            name=\"PDU Prepend Pattern Bytes\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.num_bytes = int(num_bytes)\n\n        # ----------------------------------------------------\n        # Pre-generated pattern: 8-byte sequence repeated\n        # Convert immediately to list[int] for fast concatenation\n        # ----------------------------------------------------\n        base = bytes.fromhex(\"12 34 56 78 9A BC DE F0\")\n        self.pattern_bytes = list(base * ((self.num_bytes // len(base)) + 1))\n        # Keep only exactly num_bytes length\n        self.pattern_bytes = self.pattern_bytes[:self.num_bytes]\n\n        # ----------------------------------------------------\n        # Message ports\n        # ----------------------------------------------------\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n    def handle_msg(self, msg):\n        meta = pmt.car(msg)\n        vec = pmt.cdr(msg)\n\n        # Convert incoming payload to list[int] for PMT\n        payload_list = list(pmt.u8vector_elements(vec))\n\n        # Concatenate pattern + payload (list of ints)\n        out_list = self.pattern_bytes + payload_list\n\n        # Create PMT u8vector\n        out_vec = pmt.init_u8vector(len(out_list), out_list)\n\n        # Publish new PDU\n        self.message_port_pub(\n            pmt.intern(\"out\"),\n            pmt.cons(meta, out_vec)\n        )\n\n"
    num_bytes: '10000'
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Idle + Packet Injector
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Continuous stream block with idle bytes 0xAA.
          Injects packets from input stream (Tagged Stream Mux) whenever available.
          """
          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjector",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte
              self.packet_buffer = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              n_out = len(out)
              in_len = len(inp)
              out_index = 0

              # ---- Append input bytes to internal buffer ----
              if in_len > 0:
                  self.packet_buffer.extend(inp.tolist())

              # ---- Fill output ----
              while out_index < n_out:

                  if len(self.packet_buffer) > 0:
                      # Pop from buffer
                      out[out_index] = self.packet_buffer.pop(0)
                  else:
                      # Output idle
                      out[out_index] = self.idle_byte

                  out_index += 1

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class dump_hex(gr.sync_block):
          """
          Prints bytes in hex format.
          """
          def __init__(self, label="HEX"):
              gr.sync_block.__init__(
                  self,
                  name="DumpHex",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.label = label

          def work(self, input_items, output_items):
              inp = input_items[0]

              hex_str = " ".join([f"{b:02X}" for b in inp])
              print(f"{self.label}: {hex_str}")

              return len(inp)
    label: '''HEX'''
  states: {state: disabled}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class dump_hex(gr.sync_block):
          """
          Prints bytes in hex format.
          """
          def __init__(self, label="HEX"):
              gr.sync_block.__init__(
                  self,
                  name="DumpHex",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.label = label

          def work(self, input_items, output_items):
              inp = input_items[0]

              hex_str = " ".join([f"{b:02X}" for b in inp])
              print(f"{self.label}: {hex_str}")

              return len(inp)
    label: '''HEX'''
  states: {state: disabled}
- name: epy_block_5_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class TaggedPayloadExtractor(gr.sync_block):
          """
          Tag-based payload extractor.
          - Waits for a tag with name `tag_key`.
          - Reads the first byte after the tag as payload length.
          - Forwards exactly that many bytes.
          - Discards anything else until next tag.
          """
          def __init__(self, tag_key="packet_start"):
              gr.sync_block.__init__(
                  self,
                  name="TaggedPayloadExtractor",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.tag_key = pmt.intern(tag_key)
              self.active = False
              self.bytes_remaining = 0
              self.length_byte_read = False


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)
              out_index = 0
              consumed = 0

              print(inp)

              # ---- Check for tags in current window ----
              tags = self.get_tags_in_window(0, 0, n_in)
              for t in tags:
                  if t.key == self.tag_key:
                      self.active = True
                      self.bytes_remaining = 0
                      self.length_byte_read = False

              # ---- Process input bytes ----
              for i in range(n_in):
                  if self.active:
                      if not self.length_byte_read:
                          # First byte after tag = payload length
                          self.bytes_remaining = inp[i]
                          self.length_byte_read = True
                          consumed+=1


                      elif self.bytes_remaining > 0:
                          if out_index < len(out):
                              out[out_index] = inp[i]
                              out_index += 1
                              consumed+=1
                              self.bytes_remaining -= 1
                              if self.bytes_remaining == 0:
                                  # Packet done, wait for next tag
                                  self.active = False
                                  self.length_byte_read = False

              return consumed
              #return n_in
    tag_key: '''packet_len'''
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from collections import deque

      class IdlePacketInjectorExact(gr.sync_block):
          """
          IdlePacketInjectorExact
          - Idle byte (0xAA) is output continuously until a full packet is buffered.
          - Packet format expected in rx stream: 8-byte header (header[5] = payload_len) followed by payload_len bytes.
          - When full packet is available, transmit exactly:
               [header0..7][payload_len][payload_bytes]
            (i.e., transmit the packet exactly as received)
          - Transmission is continuous at the normal flow rate; packets may span multiple work() calls.
          - While transmitting a packet, rx_buf continues to accumulate the next incoming packet.
          """

          def __init__(self, idle_byte=0xAA):
              gr.sync_block.__init__(
                  self,
                  name="IdlePacketInjectorExact",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.idle_byte = idle_byte & 0xFF

              # rx_buf: collects incoming raw bytes (deque for O(1) pops/appends)
              self.rx_buf = deque()
              # tx_buf: bytes of the packet currently being transmitted (deque)
              self.tx_buf = deque()

              # state helpers
              self.waiting_for_full_packet = True  # True when looking to form next tx_buf from rx_buf

          def _try_make_packet(self):
              """
              If rx_buf contains at least 8 bytes, read header[5] to get payload length,
              and if rx_buf contains the full packet (8 + payload_len), move those bytes
              to tx_buf (only if tx_buf is currently empty so we keep single active tx buffer).
              """
              # Only create a new tx packet if nothing is currently transmitting
              if self.tx_buf:
                  return

              # Need at least 6 bytes to read header[5] safely (indexes 0..5)
              if len(self.rx_buf) < 6:
                  return

              # Peek header[5] without popping
              # Convert deque to indexing by iterating - deque supports indexing but it's O(n).
              # Access small index directly via tuple() for efficiency when len small
              # but for clarity just use indexing (acceptable because index 5).
              payload_len = self.rx_buf[5]

              total_len = 8 + int(payload_len)  # 8-byte header + payload_len bytes

              # If we have full packet in rx_buf, move it to tx_buf
              if len(self.rx_buf) >= total_len:
                  # move the first total_len bytes from rx_buf to tx_buf in order
                  for _ in range(total_len):
                      self.tx_buf.append(self.rx_buf.popleft())

                  # Now tx_buf contains [header0..7, payload...], and will be transmitted
                  # We don't set any special flag; presence of tx_buf indicates active transmission

      # assume total_len = header_len + payload_len
                  #header = [self.rx_buf.popleft() for _ in range(8)]  # first 8 bytes of header
                  #payload = [self.rx_buf.popleft() for _ in range(total_len - 8)]  # rest of packet

      # insert payload length byte right after header
                  #payload_len_byte = total_len - 8
                  #self.tx_buf.extend(header)         # header bytes
                  #self.tx_buf.append(payload_len)  # length byte
                  #self.tx_buf.extend(payload)        # payload bytes
                  #print(self.tx_buf)


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out_index = 0

              # 1) append incoming bytes to rx_buf
              if len(inp) > 0:
                  # inp is a numpy array of uint8
                  self.rx_buf.extend(int(b) for b in inp.tolist())

              # 2) if no active tx_buf, try to assemble a packet from rx_buf
              # This also ensures back-to-back packets are handled: after finishing one,
              # next will be immediately prepared if rx_buf already contains it.
              self._try_make_packet()

              # 3) fill the output buffer at full rate.
              #    If tx_buf has data -> stream it continuously until empty,
              #    otherwise send idle bytes.
              while out_index < n_out:
                  if self.tx_buf:
                      # transmit next byte of current packet
                      out[out_index] = self.tx_buf.popleft()
                      out_index += 1

                      # after popping a byte, if tx_buf becomes empty, attempt to prepare next packet
                      if not self.tx_buf:
                          # attempt to build the next packet immediately (back-to-back)
                          self._try_make_packet()
                      # continue loop
                  else:
                      # no packet currently being transmitted -> output idle
                      out[out_index] = self.idle_byte
                      out_index += 1

                      # also after sending idle we can check if rx_buf now contains a full packet
                      # (useful if rx_buf filled during this work() call)
                      # But avoid calling _try_make_packet too often; it's cheap so ok:
                      self._try_make_packet()

              return n_out
    idle_byte: '170'
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore\nimport sys\nimport datetime\n\nclass MessageBubble(QtWidgets.QWidget):\n    def __init__(self, text, time_str, parent=None):\n        super().__init__(parent)\n        layout = QtWidgets.QHBoxLayout()\n        layout.setContentsMargins(0, 5, 0, 5)\n\n        frame = QtWidgets.QFrame()\n        frame_layout = QtWidgets.QVBoxLayout(frame)\n\n        frame.setStyleSheet(\"\"\"\n            QFrame {\n                background-color: white;\n                border-radius: 10px;\n                border: 1px solid #CCCCCC;\n            }\n        \"\"\")\n\n        lbl_text = QtWidgets.QLabel(text)\n        lbl_text.setWordWrap(True)\n        lbl_text.setStyleSheet(\"font-size: 14px; color: black;\")\n        frame_layout.addWidget(lbl_text)\n\n        meta = QtWidgets.QHBoxLayout()\n        lbl_time = QtWidgets.QLabel(time_str)\n        lbl_time.setStyleSheet(\"font-size: 10px; color: #555;\")\n        meta.addStretch()\n        meta.addWidget(lbl_time)\n        frame_layout.addLayout(meta)\n\n        layout.addWidget(frame)\n        layout.addStretch()\n        self.setLayout(layout)\n\n\nclass ChatReceiverWindow(QtWidgets.QWidget):\n    new_message_signal = QtCore.pyqtSignal(str)\n\n    def __init__(self):\n        super().__init__()\n        self.setWindowTitle(\"Received Messages\")\n        self.resize(400, 600)\n        self.setStyleSheet(\"background-color: #E6EBEF;\")\n\n        layout = QtWidgets.QVBoxLayout()\n        self.chat_area = QtWidgets.QListWidget()\n        self.chat_area.setStyleSheet(\"border: none; background-color: transparent;\")\n        layout.addWidget(self.chat_area)\n        self.setLayout(layout)\n\n        self.new_message_signal.connect(self.display)\n\n    def display(self, text):\n        time_str = datetime.datetime.now().strftime(\"%H:%M\")\n        bubble = MessageBubble(text, time_str)\n        item = QtWidgets.QListWidgetItem()\n        item.setSizeHint(bubble.sizeHint())\n        self.chat_area.addItem(item)\n        self.chat_area.setItemWidget(item, bubble)\n        self.chat_area.scrollToBottom()\n\n\nclass ChatReceiverInterface(gr.basic_block):\n\n    def __init__(self, max_packet_size=32):\n        gr.basic_block.__init__(\n            self,\n            name=\"Chat Receiver Interface GUI\",\n            in_sig=None,\n            out_sig=None)\n\n        self.max_packet_size = int(max_packet_size)\n\n        self.message_port_register_in(pmt.intern(\"pdus_in\"))\n        self.set_msg_handler(pmt.intern(\"pdus_in\"), self.handle_pdu)\n\n        self.qapp = QtWidgets.QApplication.instance()\n        if not self.qapp:\n            self.qapp = QtWidgets.QApplication(sys.argv)\n\n        self.gui = ChatReceiverWindow()\n        self.gui.show()\n\n        self.buffer = {}   # pkt_num → pdu\n\n    def handle_pdu(self, pdu):\n        meta = pmt.car(pdu)\n        vec = pmt.cdr(pdu)\n\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = list(pmt.u8vector_elements(vec))\n        pkt_len = len(data)\n        pkt_num = data[0]\n\n        print(f\"[RX] Received PDU (len={pkt_len}) pkt={pkt_num}\")\n\n        # ------------------------------------------------------\n        # TERMINATION PACKET\n        # ------------------------------------------------------\n        if pkt_len == self.max_packet_size - 1:\n            print(\"[RX] Termination packet detected.\")\n\n            full_bytes = b\"\"\n\n            for k in sorted(self.buffer.keys()):\n                p = self.buffer[k]\n                raw = list(pmt.u8vector_elements(pmt.cdr(p)))\n                full_bytes += bytes(raw[1:])  # skip pkt_num\n\n            try:\n                decoded = full_bytes.decode(\"utf-8\")\n            except:\n                decoded = \"<Decode Error>\"\n\n            # ----------- ADDED CONDITION HERE --------------\n            if decoded.strip() == \"\":\n                print(\"[RX] Empty message. Not displaying.\")\n            else:\n                self.gui.new_message_signal.emit(decoded)\n                print(\"[RX] Assembled message:\", decoded)\n            # ------------------------------------------------\n\n            self.buffer.clear()\n            return\n\n        # ------------------------------------------\n        # NORMAL PACKET\n        # ------------------------------------------\n        self.buffer[pkt_num] = pdu\n        print(f\"[RX] Stored packet {pkt_num}\")\n\n    def stop(self):\n        self.gui.close()\n        return super().stop()\n\n"
    max_packet_size: '32'
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import datetime

      class MessageBubble(QtWidgets.QWidget):
          """A custom widget to render a message bubble"""
          def __init__(self, text, time_str, status="Waiting", parent=None):
              super().__init__(parent)
              self.layout = QtWidgets.QHBoxLayout()
              self.layout.setContentsMargins(0, 5, 0, 5)

              self.container = QtWidgets.QFrame()
              self.container_layout = QtWidgets.QVBoxLayout()
              self.container.setLayout(self.container_layout)
              
              self.container.setStyleSheet("""
                  QFrame {
                      background-color: #EEFFDD; 
                      border-radius: 10px;
                      border: 1px solid #CCDDCC;
                  }
              """)

              self.lbl_text = QtWidgets.QLabel(text)
              self.lbl_text.setWordWrap(True)
              self.lbl_text.setStyleSheet("border: none; font-size: 14px; color: black;")
              self.container_layout.addWidget(self.lbl_text)

              self.meta_layout = QtWidgets.QHBoxLayout()
              self.lbl_time = QtWidgets.QLabel(time_str)
              self.lbl_time.setStyleSheet("border: none; font-size: 10px; color: #555;")
              
              self.lbl_status = QtWidgets.QLabel(status)
              self.lbl_status.setStyleSheet("border: none; font-size: 10px; font-weight: bold; color: gray;")
              
              self.meta_layout.addStretch()
              self.meta_layout.addWidget(self.lbl_time)
              self.meta_layout.addWidget(self.lbl_status)
              self.container_layout.addLayout(self.meta_layout)

              self.layout.addStretch()
              self.layout.addWidget(self.container)
              self.setLayout(self.layout)

          def set_status(self, status, color):
              self.lbl_status.setText(status)
              self.lbl_status.setStyleSheet(f"border: none; font-size: 10px; font-weight: bold; color: {color};")
              if status == "Failed":
                   self.container.setStyleSheet("QFrame { background-color: #FFDDDD; border-radius: 10px; border: 1px solid #DDAAAA; }")
              elif "Sent" in status:
                   self.container.setStyleSheet("QFrame { background-color: #EEFFDD; border-radius: 10px; border: 1px solid #CCDDCC; }")

      class ChatWindow(QtWidgets.QWidget):
          """The Telegram-style Window"""
          send_signal = QtCore.pyqtSignal(str)
          # NEW: Internal signal for thread-safe updates
          status_signal = QtCore.pyqtSignal(str, str) 

          def __init__(self):
              super().__init__()
              self.setWindowTitle("Secure Radio Chat")
              self.resize(400, 600)
              self.setStyleSheet("background-color: #E6EBEF;")

              layout = QtWidgets.QVBoxLayout()

              self.chat_area = QtWidgets.QListWidget()
              self.chat_area.setStyleSheet("border: none; background-color: transparent;")
              self.chat_area.setSelectionMode(QtWidgets.QAbstractItemView.NoSelection)
              self.chat_area.setVerticalScrollMode(QtWidgets.QAbstractItemView.ScrollPerPixel)
              layout.addWidget(self.chat_area)

              input_container = QtWidgets.QWidget()
              input_container.setStyleSheet("background-color: white; border-top: 1px solid #DDD;")
              input_layout = QtWidgets.QHBoxLayout()
              input_container.setLayout(input_layout)

              self.text_input = QtWidgets.QLineEdit()
              self.text_input.setPlaceholderText("Write a message...")
              self.text_input.returnPressed.connect(self.on_send)
              input_layout.addWidget(self.text_input)

              self.send_btn = QtWidgets.QPushButton("➤") 
              self.send_btn.setFixedSize(40, 40)
              self.send_btn.setStyleSheet("background-color: #3390EC; color: white; border-radius: 20px; font-weight: bold;")
              self.send_btn.clicked.connect(self.on_send)
              input_layout.addWidget(self.send_btn)

              layout.addWidget(input_container)
              self.setLayout(layout)

              self.current_bubble = None
              
              # Connect the signal to the update function
              self.status_signal.connect(self.update_last_status)

          def on_send(self):
              text = self.text_input.text().strip()
              if text:
                  self.text_input.clear()
                  time_str = datetime.datetime.now().strftime("%H:%M")
                  self.current_bubble = MessageBubble(text, time_str, "Sending...")
                  
                  item = QtWidgets.QListWidgetItem()
                  item.setSizeHint(self.current_bubble.sizeHint())
                  self.chat_area.addItem(item)
                  self.chat_area.setItemWidget(item, self.current_bubble)
                  self.chat_area.scrollToBottom()

                  self.send_signal.emit(text)

          def update_last_status(self, text, color):
              if self.current_bubble:
                  self.current_bubble.set_status(text, color)

      class ChatInterface(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Chat Interface (Telegram Style)",
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern("msg_out"))
              self.message_port_register_in(pmt.intern("status_in"))
              self.set_msg_handler(pmt.intern("status_in"), self.handle_status)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.gui = ChatWindow()
              self.gui.send_signal.connect(self.send_message)
              self.gui.show()

          def send_message(self, text):
              msg = pmt.intern(text)
              self.message_port_pub(pmt.intern("msg_out"), msg)

          def handle_status(self, msg):
              """Receives status updates from Block 2"""
              try:
                  status_str = pmt.symbol_to_string(msg)
                  
                  # DEBUG PRINT: Check if this appears in your GRC console!
                  print(f"[GUI] Status received: '{status_str}'")

                  if status_str == "success":
                      # Use signal to update GUI safely
                      self.gui.status_signal.emit("✓ Sent", "#3390EC")
                  elif status_str == "fail":
                      self.gui.status_signal.emit("Failed", "red")
                  elif status_str == "pending":
                      pass

              except Exception as e:
                  print(f"[GUI] Error handling status: {e}")

          def stop(self):
              self.gui.close()
              return super().stop()
  states: {}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import threading
      import time
      from gnuradio import gr

      class TextToPDU_ARQ(gr.basic_block):
          def __init__(self, max_packet_size=32, src_address=1, dest_address=2):
              gr.basic_block.__init__(
                  self,
                  name="Text to PDU (ARQ Logic)",
                  in_sig=[],
                  out_sig=[]
              )
              
              # --- CONFIGURATION (USER SETTABLE) ---
              self.interval = 0.5
              self.max_packet_size = int(max_packet_size)
              self.src_address = int(src_address) & 0xFF
              self.dest_address = int(dest_address) & 0xFF
              # -------------------------------------

              self.message_port_register_out(pmt.intern("pdus"))
              self.message_port_register_in(pmt.intern("ack_bits"))
              self.set_msg_handler(pmt.intern("ack_bits"), self.handle_ack_bits)

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_input)
              self.message_port_register_out(pmt.intern("status_out"))

              self._stop_event = threading.Event()
              self._ack_event = threading.Event()
              self._ack_lock = threading.Lock()
              self._expected_ack = None
              self._tx_lock = threading.Lock()  # Prevent overlapping transmissions

          def stop(self):
              self._stop_event.set()
              self._ack_event.set()
              return super().stop()

          def handle_msg_input(self, msg):
              text_data = pmt.symbol_to_string(msg)
              
              if self._tx_lock.locked():
                  #print("[ARQ] Busy sending previous message.")
                  return

              t = threading.Thread(target=self._process_transmission, args=(text_data,))
              t.daemon = True
              t.start()

          def _process_transmission(self, text_data):
              with self._tx_lock:
                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("pending"))
                  
                  data = text_data.encode('utf-8')
                  chunk_size = self.max_packet_size - 3
                  chunks = [data[i:i + chunk_size] for i in range(0, len(data), chunk_size)]

                  packet_number = 1
                  success = True

                  # --- SEND ALL NORMAL PACKETS ---
                  for chunk in chunks:
                      if self._stop_event.is_set():
                          success = False
                          break

                      full_packet = bytes([self.src_address, self.dest_address, packet_number]) + chunk
                      payload = pmt.init_u8vector(len(full_packet), list(full_packet))
                      pdu = pmt.cons(pmt.make_dict(), payload)

                      with self._ack_lock:
                          self._expected_ack = packet_number
                          self._ack_event.clear()

                      retry_count = 0
                      max_retries = 200
                      chunk_sent_successfully = False

                      while not self._stop_event.is_set() and retry_count < max_retries:
                          self.message_port_pub(pmt.intern("pdus"), pdu)

                          ack_received = self._ack_event.wait(timeout=self.interval)
                          if ack_received:
                              chunk_sent_successfully = True
                              break
                          else:
                              #print(f"[ARQ] Timeout waiting for ACK #{packet_number:02X}")
                              retry_count += 1

                      if not chunk_sent_successfully:
                          print(f"[ARQ] Failed to send packet #{packet_number:02X}")
                          success = False
                          break

                      packet_number = (packet_number + 1) & 0xFF
                      if packet_number == 0x00:
                          packet_number = 0x01

                  # ============================================================
                  # --- SEND TERMINATION PACKET ---
                  # ============================================================
                  if success and not self._stop_event.is_set():
                      term_packet_number = packet_number  # use next sequence

                      # termination payload size so TOTAL packet = max_packet_size + 1
                      term_payload_len = (self.max_packet_size + 1) - 3
                      term_payload = bytes([0xFF] * term_payload_len)

                      full_packet = bytes([
                          self.src_address,
                          self.dest_address,
                          term_packet_number
                      ]) + term_payload

                      payload = pmt.init_u8vector(len(full_packet), list(full_packet))
                      pdu = pmt.cons(pmt.make_dict(), payload)

                      with self._ack_lock:
                          self._expected_ack = term_packet_number
                          self._ack_event.clear()

                      retry_count = 0
                      max_retries = 200
                      term_success = False

                      while not self._stop_event.is_set() and retry_count < max_retries:
                          self.message_port_pub(pmt.intern("pdus"), pdu)

                          ack_received = self._ack_event.wait(timeout=self.interval)
                          if ack_received:
                              term_success = True
                              break
                          else:
                              print(f"[ARQ] Timeout waiting for TERMINATION ACK #{term_packet_number:02X}")
                              retry_count += 1

                      if not term_success:
                          print(f"[ARQ] Failed to send TERMINATION packet #{term_packet_number:02X}")
                          success = False

                  # ============================================================

                  if success:
                      print("[ARQ] Transmission Success. Updating GUI.")
                      self.message_port_pub(pmt.intern("status_out"), pmt.intern("success"))
                  else:
                      print("[ARQ] Transmission Failed. Updating GUI.")
                      self.message_port_pub(pmt.intern("status_out"), pmt.intern("fail"))

          def handle_ack_bits(self, msg):
              try:
                  data = pmt.cdr(msg)
                  if not pmt.is_u8vector(data):
                      return

                  byte_data = bytearray(pmt.u8vector_elements(data))
                  if len(byte_data) < 4:
                      return
                  
                  if byte_data[0] != 0xAA:
                      return

                  ack_src_addr = byte_data[1]
                  ack_dest_addr = byte_data[2]
                  ack_packet_num = byte_data[3]

                  if ack_dest_addr != self.src_address:
                      return
                  if ack_src_addr != self.dest_address:
                      return

                  with self._ack_lock:
                      if ack_packet_num == self._expected_ack:
                          print(f"[ARQ] Valid ACK received for #{ack_packet_num:02X}")
                          self._ack_event.set()
                          
              except Exception as e:
                  print(f"[ARQ] Error handling ACK: {str(e)}")
    dest_address: '2'
    max_packet_size: '32'
    src_address: '1'
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    name: ''
    size: '50'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 3,0,1,2
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    size: '20'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq1_0
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq1
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freq1
    dev_args: bladerf=0
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freq1_0
    dev_args: bladerf=0
    gain: '25.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: r2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ack
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ack
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', epy_block_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', epy_block_2, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', epy_block_5_1, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_3_1, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_6, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', epy_block_4_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_throttle2_0_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0_0, '0', zeromq_pub_sink_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', epy_block_5_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_check_0, ok, virtual_sink_2, '0']
- [digital_crc_check_0_0, ok, blocks_message_debug_1, log]
- [digital_crc_check_0_0, ok, epy_block_1_0, pdus_in]
- [digital_crc_check_0_0, ok, epy_block_3_2, pdus_in]
- [digital_crc_check_0_0, ok, epy_block_3_3, pdus_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0, '0', virtual_sink_0_0, '0']
- [digital_map_bb_0, '0', virtual_sink_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, epy_block_10, in]
- [digital_protocol_formatter_async_0, header, epy_block_4, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, pdus_out, digital_crc_append_0, in]
- [epy_block_1, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [epy_block_10, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_11, pdus, digital_crc_append_0, in]
- [epy_block_11, status_out, epy_block_8, status_in]
- [epy_block_12, pdus, digital_crc_append_0, in]
- [epy_block_12, status_out, epy_block_8, status_in]
- [epy_block_13, ack_out, digital_crc_append_0_0, in]
- [epy_block_1_0, pdus_out, epy_block_3_2, pdus_in]
- [epy_block_2, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [epy_block_2_0_0, feedback, epy_block_8, status_in]
- [epy_block_2_0_0, out, digital_crc_append_0, in]
- [epy_block_3, '0', digital_constellation_modulator_0, '0']
- [epy_block_3, '0', epy_block_5, '0']
- [epy_block_3_0, '0', digital_constellation_modulator_0, '0']
- [epy_block_3_0, '0', epy_block_5, '0']
- [epy_block_3_1, '0', digital_constellation_modulator_0, '0']
- [epy_block_3_1, '0', epy_block_5, '0']
- [epy_block_3_2, ack_packet_out, digital_crc_append_0_0, in]
- [epy_block_3_2, pdus_out, epy_block_0_0, pdus]
- [epy_block_3_3, ack_packet_out, epy_block_13, ack_in]
- [epy_block_3_3, pdus_out, epy_block_7, pdus_in]
- [epy_block_4, out, blocks_message_debug_0, log]
- [epy_block_4, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_4_0, '0', digital_constellation_modulator_0_0, '0']
- [epy_block_5_1, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [epy_block_6, '0', digital_constellation_modulator_0, '0']
- [epy_block_6, '0', epy_block_5, '0']
- [epy_block_8, msg_out, epy_block_11, msg_in]
- [epy_block_8, msg_out, epy_block_12, msg_in]
- [epy_block_8, msg_out, epy_block_2_0_0, in]
- [epy_block_8, msg_out, epy_block_9, msg_in]
- [epy_block_9, pdus, digital_crc_append_0, in]
- [epy_block_9, status_out, epy_block_8, status_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, blocks_message_debug_0_1, log]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_2, '0', epy_block_11, ack_bits]
- [virtual_source_2, '0', epy_block_12, ack_in]
- [virtual_source_2, '0', epy_block_2_0_0, ack_in]
- [virtual_source_2, '0', epy_block_9, ack_bits]
- [zeromq_sub_source_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
